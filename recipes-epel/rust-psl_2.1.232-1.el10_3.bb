# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-psl"
PV = "2.1.232"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 rust-psl+default-devel \
 rust-psl+helpers-devel \
 rust-psl-devel \
"
PACKAGES:aarch64 = " \
 rust-psl+default-devel \
 rust-psl+helpers-devel \
 rust-psl-devel \
"
PACKAGES:riscv64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-psl-2.1.232-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "479aeb7045c7aba393f8cea18a1b393af8b3ac73565ea236e321c660847f5043"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl+default-devel-2.1.232-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-psl+default-devel.sha256sum] = "4cc9aeedf9152c3e5ec10af7960545316646d1ccd00caa2d9064bf9ac29b22b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl+helpers-devel-2.1.232-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl+helpers-devel;unpack=0"
SRC_URI[x86_64_v2_rust-psl+helpers-devel.sha256sum] = "5f5102ef045f7d52b3227bdde522eff9600346d301f2744a755558beb344f7df"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl-devel-2.1.232-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-psl-devel.sha256sum] = "02f023b9f8d18062705859642c0b7df61217918a739f4506018a51048afec54b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-psl+default-devel-2.1.232-1.el10_3.noarch.rpm;name=aarch64_rust-psl+default-devel;unpack=0"
SRC_URI[aarch64_rust-psl+default-devel.sha256sum] = "539ddd81504262e67779f5f37a01cb1ab9d7744fb155663beec8071ccd3648b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-psl+helpers-devel-2.1.232-1.el10_3.noarch.rpm;name=aarch64_rust-psl+helpers-devel;unpack=0"
SRC_URI[aarch64_rust-psl+helpers-devel.sha256sum] = "1737c0d7243985b1baa8592e9ddc48ae67e05e59ca8c33936fec30ea58a54f86"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-psl-devel-2.1.232-1.el10_3.noarch.rpm;name=aarch64_rust-psl-devel;unpack=0"
SRC_URI[aarch64_rust-psl-devel.sha256sum] = "5cf778ce679816523b5ef70bcb90cd0c2ca76bf7e894a3a9dba844071c5d1b04"

RDEPENDS:rust-psl+default-devel = " \
 cargo \
 rust-psl+helpers-devel \
 rust-psl-devel \
 "
RDEPENDS:rust-psl+helpers-devel = " \
 cargo \
 rust-psl-devel \
 "
RDEPENDS:rust-psl-devel = " \
 cargo \
 rust-psl-types+default-devel \
 "
