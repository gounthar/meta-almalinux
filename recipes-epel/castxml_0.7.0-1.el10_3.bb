# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "castxml"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 castxml \
"
PACKAGES:aarch64 = " \
 castxml \
"
PACKAGES:riscv64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/castxml-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b944c3d5a61d62799aed5d0c83f5b2899b800daab4b8845a472ef3f10037b582"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - castxml: libLLVM.so.21.1()(64bit)
# - castxml: libLLVM.so.21.1(LLVM_21.1)(64bit)
# - castxml: libclang-cpp.so.21.1()(64bit)
# - castxml: libclang-cpp.so.21.1(LLVM_21.1)(64bit)

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/castxml-0.7.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_castxml;unpack=0"
SRC_URI[x86_64_v2_castxml.sha256sum] = "9a448e6d7001ea9a984c20b0bad2c4bc3318d4dc1def76ddf682fa49adbcf4f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/castxml-0.7.0-1.el10_3.aarch64.rpm;name=aarch64_castxml;unpack=0"
SRC_URI[aarch64_castxml.sha256sum] = "87bb114f4fc8369022ac023ad6e8f9ef08d9a6afb10fabe11ca862e3a72ffe34"

RDEPENDS:castxml:x86_64_v2 = " \
 glibc \
 libgcc \
 libstdc++ \
"
RDEPENDS:castxml:aarch64 = " \
 clang21-libs \
 glibc \
 libgcc \
 libstdc++ \
 llvm21-libs \
"
