# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-rustls"
PV = "0.26.5"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 rust-tokio-rustls+brotli-devel \
 rust-tokio-rustls+default-devel \
 rust-tokio-rustls+early-data-devel \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls+zlib-devel \
 rust-tokio-rustls-devel \
"
PACKAGES:aarch64 = " \
 rust-tokio-rustls+brotli-devel \
 rust-tokio-rustls+default-devel \
 rust-tokio-rustls+early-data-devel \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls+zlib-devel \
 rust-tokio-rustls-devel \
"
PACKAGES:riscv64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-rustls-0.26.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "178fdff9b9e5c1ba47faa24c01fb1d31f6cc2abd7a4c6ce6f3b509d10410d646"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+brotli-devel-0.26.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+brotli-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+brotli-devel.sha256sum] = "12504a0e0e511c2b493ffb6b717882c8a7257e76962d568ca570850ee152b382"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+default-devel-0.26.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+default-devel.sha256sum] = "093f170ff5f30bb8d79592ff185c48fc67bbad5ddb6b843b17a153c5daa5bc9f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+early-data-devel-0.26.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+early-data-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+early-data-devel.sha256sum] = "2bb467585463b19350cf51235f009313a583ed16024f0ab233c787b8079ce8aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+logging-devel-0.26.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+logging-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+logging-devel.sha256sum] = "08797bf6880b8da443ac18321644128ff62d953a657ff372b3bc9e59acb41c7d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+ring-devel-0.26.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+ring-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+ring-devel.sha256sum] = "56d7974d5a51a5e506621e8d627c2615f19178bec4e92dd71fee590f17c917b8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+tls12-devel-0.26.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+tls12-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+tls12-devel.sha256sum] = "0219e007589e3ee34d6f19cab013a871866f1232e3a2f1e11335c3711f1b0b53"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+zlib-devel-0.26.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+zlib-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+zlib-devel.sha256sum] = "3913a12acd94d738c92e9088cfcf6a873ccda0f8a45949ae232ac195b2373f5d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls-devel-0.26.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls-devel.sha256sum] = "fb54aec386e4758db34b487a0f922df83620b328a78d33c6c2dd7694d9c1d523"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+brotli-devel-0.26.5-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls+brotli-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+brotli-devel.sha256sum] = "347f219ed297ceda4cd9219b605583f83175755f301931db135befe817547429"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+default-devel-0.26.5-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls+default-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+default-devel.sha256sum] = "cb70ca60089b312a63cc974141eb1658604b909321e2e6feb67378567ce02db7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+early-data-devel-0.26.5-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls+early-data-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+early-data-devel.sha256sum] = "84cbd84cd40d88c5b001aa4a59c7e81e119be969f0e7e5acc7b2f79df246f39c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+logging-devel-0.26.5-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls+logging-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+logging-devel.sha256sum] = "f5e7464dc177cd89187aa3c4e445e5e9fde7c3ceabfccb4ed9ee9bd6050ba533"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+ring-devel-0.26.5-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls+ring-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+ring-devel.sha256sum] = "e94e5780a3a185a0699212295deeb28047809a5db15780442967671f81fa9216"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+tls12-devel-0.26.5-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls+tls12-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+tls12-devel.sha256sum] = "5a9391b9ffac996d8d581e8361a24e0a2e5d1ec13262f78a2b57a593cd520488"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+zlib-devel-0.26.5-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls+zlib-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+zlib-devel.sha256sum] = "35fc0a392d7c16af0107c77ef3088b9a45a68403a37f545cfbc9bd4159f72aa0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls-devel-0.26.5-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-rustls-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls-devel.sha256sum] = "049d14d3fe98ea547c92f5a15b7db0e267a9577fbd1f76613a1da5f328281be3"

RDEPENDS:rust-tokio-rustls+brotli-devel = " \
 cargo \
 rust-rustls+brotli-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+default-devel = " \
 cargo \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+early-data-devel = " \
 cargo \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+logging-devel = " \
 cargo \
 rust-rustls+logging-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+ring-devel = " \
 cargo \
 rust-rustls+ring-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+tls12-devel = " \
 cargo \
 rust-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+zlib-devel = " \
 cargo \
 rust-rustls+zlib-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls-devel = " \
 cargo \
 rust \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-tokio+default-devel \
 "
