# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-cert-store"
PV = "0.7.4"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 rust-sequoia-cert-store+default-devel \
 rust-sequoia-cert-store+keyserver-devel \
 rust-sequoia-cert-store-devel \
"
PACKAGES:aarch64 = " \
 rust-sequoia-cert-store+default-devel \
 rust-sequoia-cert-store+keyserver-devel \
 rust-sequoia-cert-store-devel \
"
PACKAGES:riscv64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-sequoia-cert-store-0.7.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "01659d12dcc6fdc51ed4a199e161561b30b9bc7ea6f24ec89bb75145e7062976"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-cert-store+default-devel-0.7.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-cert-store+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-cert-store+default-devel.sha256sum] = "bce33ec6dd98b0ad3efc0ba5590de95b99ca8a1f7e25fceae10a74be9ab5a207"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-cert-store+keyserver-devel-0.7.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-cert-store+keyserver-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-cert-store+keyserver-devel.sha256sum] = "5529c8d0c60ce8e5255512bb07ec2c4e6fc75f4a86df624bdba7726349eb0cd1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-cert-store-devel-0.7.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-cert-store-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-cert-store-devel.sha256sum] = "4e5327aac463dbe72896b0865133c278990315713f289663936be5a13b02e788"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-cert-store+default-devel-0.7.4-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-cert-store+default-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-cert-store+default-devel.sha256sum] = "6b278eaa2d6f6096f028ca6820ef24761a56ba0d4b016a590dc0855eeb9fa2e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-cert-store+keyserver-devel-0.7.4-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-cert-store+keyserver-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-cert-store+keyserver-devel.sha256sum] = "0676b489f13497933f04f3956aeb40ce5a69f3b6a465493e0d4ce7813021cace"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-cert-store-devel-0.7.4-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-cert-store-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-cert-store-devel.sha256sum] = "b06aef2db706a8a95ce7d2656ba2fdaefc2cc3bd13491fc00af36ee6a8e36859"

RDEPENDS:rust-sequoia-cert-store+default-devel = " \
 cargo \
 rust-sequoia-cert-store+keyserver-devel \
 rust-sequoia-cert-store-devel \
 "
RDEPENDS:rust-sequoia-cert-store+keyserver-devel = " \
 cargo \
 rust-sequoia-cert-store-devel \
 rust-sequoia-net-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 "
RDEPENDS:rust-sequoia-cert-store-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-crossbeam+default-devel \
 rust-dirs+default-devel \
 rust-gethostname+default-devel \
 rust-num_cpus+default-devel \
 rust-openpgp-cert-d-devel \
 rust-rayon+default-devel \
 rust-sequoia-openpgp-devel \
 rust-smallvec+default-devel \
 rust-url+default-devel \
 virtual/crate_rusqlite/blob__ge_0.29.0_with_crate_rusqlite/blob__lt_0.41.0~ \
 virtual/crate_rusqlite/collation__ge_0.29.0_with_crate_rusqlite/collation__lt_0.41.0~ \
 virtual/crate_rusqlite/default__ge_0.29.0_with_crate_rusqlite/default__lt_0.41.0~ \
 virtual/crate_rusqlite/trace__ge_0.29.0_with_crate_rusqlite/trace__lt_0.41.0~ \
 virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~ \
 "
