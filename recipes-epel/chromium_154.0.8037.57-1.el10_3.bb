# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chromium"
PV = "154.0.8037.57"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 chromedriver \
 chromium \
 chromium-common \
 chromium-headless \
 chromium-qt5-ui \
 chromium-qt6-ui \
"
PACKAGES:aarch64 = " \
 chromedriver \
 chromium \
 chromium-common \
 chromium-headless \
 chromium-qt5-ui \
 chromium-qt6-ui \
"
PACKAGES:riscv64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/chromium-154.0.8037.57-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bb79b374335e5553a217904b9d6132b0efb0eb73a065561bbac0fbc0d86c3aef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromedriver-154.0.8037.57-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromedriver;unpack=0"
SRC_URI[x86_64_v2_chromedriver.sha256sum] = "f280561ffb1ec0ab28bf7e12b9a815ee0088d69b058a01dbe85b07f42084ddb1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-154.0.8037.57-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium;unpack=0"
SRC_URI[x86_64_v2_chromium.sha256sum] = "2271c349b482327a5d7106b28489cdff5c81e7cd53db42565e05b74fdb8495b9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-common-154.0.8037.57-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-common;unpack=0"
SRC_URI[x86_64_v2_chromium-common.sha256sum] = "ad380b9faae3bde8c436d21d71e63ac6d10ae23c3046bb5416e0a629c59c20a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-headless-154.0.8037.57-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-headless;unpack=0"
SRC_URI[x86_64_v2_chromium-headless.sha256sum] = "fa62fc3ca1e074a33258f58060da4c6d762b936ac9faf177b92f2cd08c36014e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-qt5-ui-154.0.8037.57-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-qt5-ui;unpack=0"
SRC_URI[x86_64_v2_chromium-qt5-ui.sha256sum] = "2d0bca7505bd3e805eab2d434c97c623e2918dd50b73a81f374c5e9fff00eb84"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-qt6-ui-154.0.8037.57-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-qt6-ui;unpack=0"
SRC_URI[x86_64_v2_chromium-qt6-ui.sha256sum] = "c4a0cef5b777701dc6d3ceb72c9acfe2d0ab320bc16736e3dc194a8ff285ca95"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromedriver-154.0.8037.57-1.el10_3.aarch64.rpm;name=aarch64_chromedriver;unpack=0"
SRC_URI[aarch64_chromedriver.sha256sum] = "1b0c31fadabd1d8ea4b48921138422899310c3ca1d672884b498dc2c3f7f62e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromium-154.0.8037.57-1.el10_3.aarch64.rpm;name=aarch64_chromium;unpack=0"
SRC_URI[aarch64_chromium.sha256sum] = "e4b0f2cc5084cd0d10b76e2454cc87b7b4b7c42653c954bcb36df48425099d43"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromium-common-154.0.8037.57-1.el10_3.aarch64.rpm;name=aarch64_chromium-common;unpack=0"
SRC_URI[aarch64_chromium-common.sha256sum] = "c24fc262c6ccdbef9c55eaccf34db24ed770b50832b96ae7e5634321be0a49fb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromium-headless-154.0.8037.57-1.el10_3.aarch64.rpm;name=aarch64_chromium-headless;unpack=0"
SRC_URI[aarch64_chromium-headless.sha256sum] = "33ea5d51b116174c9b0a5c5bcf309b8ddbc5ed0dfd4dd97176b696a408fa07c1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromium-qt5-ui-154.0.8037.57-1.el10_3.aarch64.rpm;name=aarch64_chromium-qt5-ui;unpack=0"
SRC_URI[aarch64_chromium-qt5-ui.sha256sum] = "a3681f3b7b28112fca01bd14d7255d0d9841af391139f8ba9b0ced3163fb9101"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromium-qt6-ui-154.0.8037.57-1.el10_3.aarch64.rpm;name=aarch64_chromium-qt6-ui;unpack=0"
SRC_URI[aarch64_chromium-qt6-ui.sha256sum] = "6abffdd11c50f55f5470bd323a06f4e728e4d94498690816c131a95f38c441ca"

RDEPENDS:chromedriver = " \
 chromium-common \
 double-conversion \
 glib2 \
 glibc \
 libbrotli \
 libgcc \
 libxcb \
 libzstd \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:chromium = " \
 alsa-lib \
 at-spi2-atk \
 at-spi2-core \
 atk \
 bash \
 cairo \
 chromium-common \
 cups-libs \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 gtk4 \
 harfbuzz \
 lcms2 \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbrotli \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libusb1 \
 libwebp \
 libxcb \
 libxkbcommon \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-mdns \
 nss-util \
 openjpeg2 \
 opus \
 pango \
 pipewire-libs \
 policycoreutils \
 policycoreutils-python-utils \
 systemd-libs \
 "
RDEPENDS:chromium-common = " \
 glibc \
 libgcc \
 "
RDEPENDS:chromium-headless = " \
 alsa-lib \
 at-spi2-core \
 atk \
 chromium-common \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 harfbuzz \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbrotli \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libwebp \
 libxcb \
 libxkbcommon \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-util \
 opus \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:chromium-qt5-ui = " \
 chromium \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:chromium-qt6-ui = " \
 chromium \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
