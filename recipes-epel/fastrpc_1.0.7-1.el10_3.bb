# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fastrpc"
PV = "1.0.7"
PR = "1.el10_3"
PACKAGES:aarch64 = " \
 fastrpc \
 fastrpc-devel \
 fastrpc-services \
"
PACKAGES:riscv64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fastrpc-1.0.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b18fa1e17289fe2b96c2ef438dde3e0c612852ffc9ecddbf5911c68e6c6b86db"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fastrpc-1.0.7-1.el10_3.aarch64.rpm;name=aarch64_fastrpc;unpack=0"
SRC_URI[aarch64_fastrpc.sha256sum] = "1f6fe1ea095206f422e9ba28b1e3410e2b25e2e1555a8ba3fb03c186a2517b4d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fastrpc-devel-1.0.7-1.el10_3.aarch64.rpm;name=aarch64_fastrpc-devel;unpack=0"
SRC_URI[aarch64_fastrpc-devel.sha256sum] = "64da21bacebf7628fcb806c57cbbaaf139d6875ecdd3888c22d576f2c8bf180a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fastrpc-services-1.0.7-1.el10_3.aarch64.rpm;name=aarch64_fastrpc-services;unpack=0"
SRC_URI[aarch64_fastrpc-services.sha256sum] = "a68409da21a7144b41ad7d4c8230df26b07a31e2942897039311693161f95e7e"

RDEPENDS:fastrpc = " \
 glibc \
 libbsd \
 libyaml \
 "
RDEPENDS:fastrpc-devel = " \
 fastrpc \
 "
RDEPENDS:fastrpc-services = " \
 bash \
 fastrpc \
 glibc \
 "
