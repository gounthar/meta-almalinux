# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-configargparse"
PV = "1.7.7"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 python3-configargparse \
 python3-configargparse+yaml \
"
PACKAGES:aarch64 = " \
 python3-configargparse \
 python3-configargparse+yaml \
"
PACKAGES:riscv64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-configargparse-1.7.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d957e45fc64a5e834ad09a53f40bd9ae0c4dc2d4533905e3c830c4a5c764d82d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-configargparse-1.7.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-configargparse;unpack=0"
SRC_URI[x86_64_v2_python3-configargparse.sha256sum] = "6fa955d6daefc3f41fbd0576267ab3bdb8acf1413410103b775038de18386790"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-configargparse+yaml-1.7.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-configargparse+yaml;unpack=0"
SRC_URI[x86_64_v2_python3-configargparse+yaml.sha256sum] = "d76ff8ee0742dacc17723115fe962250409f5940f875d8f813d03faa4833a625"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-configargparse-1.7.7-1.el10_3.noarch.rpm;name=aarch64_python3-configargparse;unpack=0"
SRC_URI[aarch64_python3-configargparse.sha256sum] = "6fadf2ca2a69a186e4596266e2b4d24cf6742013cb8323472e05cb6469cf1613"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-configargparse+yaml-1.7.7-1.el10_3.noarch.rpm;name=aarch64_python3-configargparse+yaml;unpack=0"
SRC_URI[aarch64_python3-configargparse+yaml.sha256sum] = "0d6c2d283227b4ea034a018f43cff8985fd7f7c57bebe327a8e206d95cb959b8"

RDEPENDS:python3-configargparse = " \
 python3 \
 "
RDEPENDS:python3-configargparse+yaml = " \
 python3 \
 python3-configargparse \
 python3-pyyaml \
 "
