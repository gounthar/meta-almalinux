# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi"
PV = "11.0.2"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 dracut-kiwi-lib \
 dracut-kiwi-live \
 dracut-kiwi-oem-dump \
 dracut-kiwi-oem-repart \
 dracut-kiwi-overlay \
 dracut-kiwi-verity \
 kiwi-cli \
 kiwi-pxeboot \
 kiwi-selinux \
 kiwi-systemdeps \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-image-validation \
 kiwi-systemdeps-iso-media \
 python3-kiwi \
"
PACKAGES:aarch64 = " \
 dracut-kiwi-lib \
 dracut-kiwi-live \
 dracut-kiwi-oem-dump \
 dracut-kiwi-oem-repart \
 dracut-kiwi-overlay \
 dracut-kiwi-verity \
 kiwi-cli \
 kiwi-selinux \
 kiwi-systemdeps \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-image-validation \
 kiwi-systemdeps-iso-media \
 python3-kiwi \
"
PACKAGES:riscv64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kiwi-11.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d98a3c69fb966f456b4de97c6611c7d4f406df22a2119c8fda12d87722835b35"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-lib-11.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-lib;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-lib.sha256sum] = "724511419777b1decc183b8044d08ad13669e8ee55df75b19a026a245b09bedc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-live-11.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-live;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-live.sha256sum] = "ea12f966480063921fd901b580d57bbb4d8d029095eba3993014d1e7c1d222d3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-oem-dump-11.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-oem-dump;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-oem-dump.sha256sum] = "61bf0338d13567f55db3705dd5e0a56e49b0bbb7b5951fe39c4768ef4d95b04b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-oem-repart-11.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-oem-repart;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-oem-repart.sha256sum] = "d14d30d3c2f0118b034575e53c6fce5c8f84e63a6677434ae288e976746121e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-overlay-11.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-overlay;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-overlay.sha256sum] = "808ebc8bc55def8afcc9f1193a4981bac0aefbcf064fa5df016e90a54dbca894"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-verity-11.0.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dracut-kiwi-verity;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-verity.sha256sum] = "3d242e0d0d9c7928704a1b97be19a948a3e719d80914289c0be3a335a0167b94"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-cli-11.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-cli;unpack=0"
SRC_URI[x86_64_v2_kiwi-cli.sha256sum] = "9bd7026a97997964482f3cac7a4d18344e541e321ee6a665e7b82456126796d3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-pxeboot-11.0.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-pxeboot;unpack=0"
SRC_URI[x86_64_v2_kiwi-pxeboot.sha256sum] = "5c4b484cb6db13919f8997d6bcb6348fd053e95c34105d1a92e6cbbcb4bd7bf1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-selinux-11.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-selinux;unpack=0"
SRC_URI[x86_64_v2_kiwi-selinux.sha256sum] = "19715b6c750812ca6054377b15c1a64d888bd78750d10eefe6bd89de17e5f3f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-11.0.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps.sha256sum] = "0888bfe1bbd1a26a4d908b40c975df3889cdc53c34b07a0ffc4129e50b34cfdf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-bootloaders-11.0.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-bootloaders;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-bootloaders.sha256sum] = "e74b6009e061bbe7153ba02b658085a7b5a12999436cf0ae52426ec6bd3e366d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-containers-11.0.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-containers;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-containers.sha256sum] = "a1f1a6baae9bc379fb0c5d5f96acf484bf6c45a3baf16c68c43f4cc3c0b2af8e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-core-11.0.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-core;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-core.sha256sum] = "02642d8a23dab5e0bd4e8479a0c4be8b34c0ba75bdbc9d86139a8cdfcc8fe3db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-disk-images-11.0.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-disk-images;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-disk-images.sha256sum] = "1f8e3b1aaeb44418b240c4265a5ab6bb7a917877da4c3f50afbccb9106f419f8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-filesystems-11.0.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-filesystems;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-filesystems.sha256sum] = "d86bdf20592a7769febede6e925a69fb905ba2cf79c1855989d9b5c9cd20d3cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-image-validation-11.0.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-image-validation;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-image-validation.sha256sum] = "e26c6b9d3557f2d3faf0815e2d957d55319b01744e1d66b33097bc50291800a4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-iso-media-11.0.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-iso-media;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-iso-media.sha256sum] = "4e572757d918f031f1777dd3095a2f54644fa4a659c0c03e07776f21c81255d4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-11.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi;unpack=0"
SRC_URI[x86_64_v2_python3-kiwi.sha256sum] = "d603b6f5f2b8a4e3bc853dc3035a3f2997e8e86b49c617ee97c41c7526f411e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-lib-11.0.2-1.el10_3.noarch.rpm;name=aarch64_dracut-kiwi-lib;unpack=0"
SRC_URI[aarch64_dracut-kiwi-lib.sha256sum] = "d4866bb8be09d20c79cd9200404e8566f3c7323d5158b21d4a9b0348a9854284"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-live-11.0.2-1.el10_3.noarch.rpm;name=aarch64_dracut-kiwi-live;unpack=0"
SRC_URI[aarch64_dracut-kiwi-live.sha256sum] = "ab3786e625bdeb85f792b2e57a2d688af9109ac1743245b1a5839e0fcba7d3aa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-oem-dump-11.0.2-1.el10_3.noarch.rpm;name=aarch64_dracut-kiwi-oem-dump;unpack=0"
SRC_URI[aarch64_dracut-kiwi-oem-dump.sha256sum] = "991944eacf03a22f1d98d035bd4c044771eb84b9b3501a6e22920476fc85abed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-oem-repart-11.0.2-1.el10_3.noarch.rpm;name=aarch64_dracut-kiwi-oem-repart;unpack=0"
SRC_URI[aarch64_dracut-kiwi-oem-repart.sha256sum] = "af1bbbc7d1318b3a841e5455947c76ec4db2bf099fbc2a9a17952d9d4af8ae94"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-overlay-11.0.2-1.el10_3.noarch.rpm;name=aarch64_dracut-kiwi-overlay;unpack=0"
SRC_URI[aarch64_dracut-kiwi-overlay.sha256sum] = "2d23120ab4d05d9b2a5bdd573f291186eeaffd331e9dcc05c76fb8f4feeec073"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-verity-11.0.2-1.el10_3.aarch64.rpm;name=aarch64_dracut-kiwi-verity;unpack=0"
SRC_URI[aarch64_dracut-kiwi-verity.sha256sum] = "8b294a865df197e7ec7ccc963696be3fe8ad3070b0f9352c0cdd1f0ef7b97cb1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-cli-11.0.2-1.el10_3.noarch.rpm;name=aarch64_kiwi-cli;unpack=0"
SRC_URI[aarch64_kiwi-cli.sha256sum] = "aab309e87955609c4dcdcd52380a0f048b53198cb8b287b14d94562429269996"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-selinux-11.0.2-1.el10_3.noarch.rpm;name=aarch64_kiwi-selinux;unpack=0"
SRC_URI[aarch64_kiwi-selinux.sha256sum] = "0267837f3411a3ef6ad56397b505803b3256680f83b9d04c558112ffd499197e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-11.0.2-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps.sha256sum] = "9203a6d0478e380f034ee6c7f012083ac7e9ad8e5138e526310d487a34e9ec97"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-bootloaders-11.0.2-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-bootloaders;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-bootloaders.sha256sum] = "d37a8f298612ec1094a13778797bcd5044816e11e999154026944f4f5bdc14bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-containers-11.0.2-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-containers;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-containers.sha256sum] = "c9978b6a19a03b85f51bd42b3ff308b6d713e0b81e8a34ada46c666bc39196ac"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-core-11.0.2-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-core;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-core.sha256sum] = "d787c1e29450b28ec342f0fbe3c2e8b629f943937e6f86f22818d74a0de59399"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-disk-images-11.0.2-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-disk-images;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-disk-images.sha256sum] = "4b3174038393e4a7faf8ce13b517cc821526a9b72c0955497979d3d8210c0187"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-filesystems-11.0.2-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-filesystems;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-filesystems.sha256sum] = "39b53fd5c192304f5ee19e4cf92401ef53990f1781f96a27561887df09bf4893"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-image-validation-11.0.2-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-image-validation;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-image-validation.sha256sum] = "ccbc7b9f2c28cbdc7b74296faba98c65bdc7a0fb1ffa7f385f99cbec3587ab57"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-iso-media-11.0.2-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-iso-media;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-iso-media.sha256sum] = "05d2bff2fe840c0482b8fe2c33cfdb91475fdaad6f98e6ab3d6805787a4bbd76"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-11.0.2-1.el10_3.noarch.rpm;name=aarch64_python3-kiwi;unpack=0"
SRC_URI[aarch64_python3-kiwi.sha256sum] = "78aff8cd924434f2b7c94bc35343ff647e3a72b8873b4111b0246c2ab8ab6e07"

RDEPENDS:dracut-kiwi-lib = " \
 bash \
 bc \
 cryptsetup \
 curl \
 device-mapper \
 dialog \
 dracut \
 e2fsprogs \
 gdisk \
 grep \
 kpartx \
 lvm2 \
 mdadm \
 parted \
 pv \
 util-linux \
 virtual/coreutils \
 xfsprogs \
 xz \
 "
RDEPENDS:dracut-kiwi-live = " \
 bash \
 device-mapper \
 dialog \
 dracut \
 dracut-kiwi-lib \
 dracut-network \
 e2fsprogs \
 parted \
 util-linux \
 xfsprogs \
 "
RDEPENDS:dracut-kiwi-oem-dump = " \
 bash \
 dracut-kiwi-lib \
 gawk \
 kexec-tools \
 "
RDEPENDS:dracut-kiwi-oem-repart = " \
 bash \
 dracut-kiwi-lib \
 "
RDEPENDS:dracut-kiwi-overlay = " \
 bash \
 dracut \
 dracut-kiwi-lib \
 util-linux \
 "
RDEPENDS:dracut-kiwi-verity = " \
 bash \
 dracut \
 dracut-kiwi-lib \
 glibc \
 "
RDEPENDS:kiwi-cli = " \
 bash-completion \
 kiwi-selinux \
 python3-kiwi \
 "
RDEPENDS:kiwi-pxeboot = " \
 syslinux \
 tftp-server \
 "
RDEPENDS:kiwi-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
RDEPENDS:kiwi-systemdeps = " \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-iso-media \
 "
RDEPENDS:kiwi-systemdeps-bootloaders:x86_64_v2 = " \
 grub2-efi-x64 \
 grub2-efi-x64-modules \
 grub2-pc \
 grub2-pc-modules \
 grub2-tools \
 grub2-tools-efi \
 grub2-tools-extra \
 grub2-tools-minimal \
 kiwi-systemdeps-core \
"
RDEPENDS:kiwi-systemdeps-bootloaders:aarch64 = " \
 grub2-efi-aa64-modules \
 grub2-tools \
 grub2-tools-extra \
 grub2-tools-minimal \
 kiwi-systemdeps-core \
"
RDEPENDS:kiwi-systemdeps-containers = " \
 appx-util \
 buildah \
 skopeo \
 "
RDEPENDS:kiwi-systemdeps-core = " \
 dnf \
 file \
 lsof \
 microdnf \
 mtools \
 openssl \
 python3-dnf \
 rsync \
 screen \
 sed \
 tar \
 xz \
 "
RDEPENDS:kiwi-systemdeps-disk-images = " \
 cryptsetup \
 gdisk \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-iso-media \
 kpartx \
 lvm2 \
 mdadm \
 open-vmdk \
 util-linux \
 "
RDEPENDS:kiwi-systemdeps-filesystems = " \
 dosfstools \
 e2fsprogs \
 erofs-utils \
 kiwi-systemdeps-core \
 qemu-img \
 squashfs-tools \
 xfsprogs \
 "
RDEPENDS:kiwi-systemdeps-image-validation = " \
 python3-solv \
 "
RDEPENDS:kiwi-systemdeps-iso-media:x86_64_v2 = " \
 grub2-efi-x64-cdboot \
 isomd5sum \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-core \
 kiwi-systemdeps-filesystems \
 syslinux \
 syslinux-nonlinux \
 xorriso \
"
RDEPENDS:kiwi-systemdeps-iso-media:aarch64 = " \
 grub2-efi-aa64-cdboot \
 isomd5sum \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-core \
 kiwi-systemdeps-filesystems \
 xorriso \
"
RDEPENDS:python3-kiwi = " \
 kiwi-systemdeps-core \
 python3 \
 python3-lxml \
 python3-pyyaml \
 python3-requests \
 python3-simplejson \
 python3-typer \
 "
