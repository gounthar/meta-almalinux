# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-syn"
PV = "3.0.5"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 rust-syn+clone-impls-devel \
 rust-syn+default-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+test-devel \
 rust-syn+visit-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
"
PACKAGES:aarch64 = " \
 rust-syn+clone-impls-devel \
 rust-syn+default-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+test-devel \
 rust-syn+visit-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
"
PACKAGES:riscv64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-syn-3.0.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1c659523a573fd8ea5cc70cece18279f3021ec3b7f28d6cee0e41ce72bd25fed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+clone-impls-devel-3.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+clone-impls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+clone-impls-devel.sha256sum] = "d27d0dc813fcd389a76796aa2aac60fb9f58693b585e6630e6d5e935d6024fdc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+default-devel-3.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+default-devel.sha256sum] = "e2cb09b3a92d50b9bc5ba31bed7a9a855d4ec9483feff8cfc13480eed5c8f121"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+derive-devel-3.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+derive-devel.sha256sum] = "d1a96555d659e0a1fed0fc2c23e8c79314930c7f690cc70aca525b1a0f2709e5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+extra-traits-devel-3.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+extra-traits-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+extra-traits-devel.sha256sum] = "e301efcc6d63aa9e55266ef3916f0de496b4766d5a491ef0f7d62c8f787f65b9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+fold-devel-3.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+fold-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+fold-devel.sha256sum] = "d4e4d6431a225aae8d829a6942e57acbc1774cb7db097a699ac221c028ea9e18"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+full-devel-3.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+full-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+full-devel.sha256sum] = "1c7c0c3a23763912b3f1acb1d2aebc3f0883ac9cf3ab96b8082ec22b902991ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+parsing-devel-3.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+parsing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+parsing-devel.sha256sum] = "e7446cf6cd5eb81fdb89d536321bcdc5559a0e26807ebf5b08ca10a72d0ee9e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+printing-devel-3.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+printing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+printing-devel.sha256sum] = "1667bba5a74a2d9e5cbb045c3ac42fc9b9a9fa57bf406f9b823d1847d3bc00d4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+proc-macro-devel-3.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+proc-macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+proc-macro-devel.sha256sum] = "80a9650ed81ea7e67aafa40cc62410ddb217866d4d5680ef541d42b4d1d9bde5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+test-devel-3.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+test-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+test-devel.sha256sum] = "7dd44285eb2ebed8eb74a36b408b0d38d9324fb8204e861800ac899e29127799"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+visit-devel-3.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+visit-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+visit-devel.sha256sum] = "77d08e1d6a3888f8525381bd64f09ff83a42ea931538789726ee6bef7848b4ad"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+visit-mut-devel-3.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+visit-mut-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn+visit-mut-devel.sha256sum] = "491d6c7d374a9f6617e0e71a32cefb97cea7348d6d35dc9fb95fd3333790e1b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn-devel-3.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn-devel;unpack=0"
SRC_URI[x86_64_v2_rust-syn-devel.sha256sum] = "4749873740f3b5f0f04ec703ba4174d3005e0df6e17114e906fca9260325a09e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+clone-impls-devel-3.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-syn+clone-impls-devel;unpack=0"
SRC_URI[aarch64_rust-syn+clone-impls-devel.sha256sum] = "a25f817fef201fac4ceb453b1846d3489236c34caaa357c349b1b9b23b935218"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+default-devel-3.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-syn+default-devel;unpack=0"
SRC_URI[aarch64_rust-syn+default-devel.sha256sum] = "0c683ebf5004053cac4eddfacdeacf164911eb128f0e6e1beb96b965854c20d2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+derive-devel-3.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-syn+derive-devel;unpack=0"
SRC_URI[aarch64_rust-syn+derive-devel.sha256sum] = "b67d8f51f9dba42544acc0cca7cacd252f5f14befc4df8c518dc163ec70b2913"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+extra-traits-devel-3.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-syn+extra-traits-devel;unpack=0"
SRC_URI[aarch64_rust-syn+extra-traits-devel.sha256sum] = "b21df214ab8f8738db9f7a856abbddc02496f903842ba1657b32bd69451d8b90"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+fold-devel-3.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-syn+fold-devel;unpack=0"
SRC_URI[aarch64_rust-syn+fold-devel.sha256sum] = "85ac6cd698c3f979692e484ededb2ac7f189b452a178b5c1a40bdc23045e3414"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+full-devel-3.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-syn+full-devel;unpack=0"
SRC_URI[aarch64_rust-syn+full-devel.sha256sum] = "2761f5a9462993692941a17edc90e7899dcaa1f2bfff018a200400d37d9132af"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+parsing-devel-3.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-syn+parsing-devel;unpack=0"
SRC_URI[aarch64_rust-syn+parsing-devel.sha256sum] = "31c5483bc32c14308ecf6523d79e9ffb0fd1174f85ed834439a40d9213021d87"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+printing-devel-3.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-syn+printing-devel;unpack=0"
SRC_URI[aarch64_rust-syn+printing-devel.sha256sum] = "168007052381a6ba1826fe48e7263182105ed579dca09e3a0f4fd5144462f746"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+proc-macro-devel-3.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-syn+proc-macro-devel;unpack=0"
SRC_URI[aarch64_rust-syn+proc-macro-devel.sha256sum] = "7be1585e442aea219744c39547b3dcb23d885b98f4c6c688c53710db673c5f09"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+test-devel-3.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-syn+test-devel;unpack=0"
SRC_URI[aarch64_rust-syn+test-devel.sha256sum] = "bbb493bb1bdea685171b8ca8bbcb3f1951b608be81ec4fffe5af27093e6dafe5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+visit-devel-3.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-syn+visit-devel;unpack=0"
SRC_URI[aarch64_rust-syn+visit-devel.sha256sum] = "22fb1809d7df08dc264a3b031931756271f9c723522478068deb8dfc7c5029c4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+visit-mut-devel-3.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-syn+visit-mut-devel;unpack=0"
SRC_URI[aarch64_rust-syn+visit-mut-devel.sha256sum] = "7f204203cab7ced98c24ce30aa57f0271c0e7e24625c62dfee5d34c5f81ac0ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-syn-devel-3.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-syn-devel;unpack=0"
SRC_URI[aarch64_rust-syn-devel.sha256sum] = "c909633e4be9b3722219a2e2f2054633ed56ac6ca1d153516ba826189a2dd0fc"

RDEPENDS:rust-syn+clone-impls-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+default-devel = " \
 cargo \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+derive-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+extra-traits-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+fold-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+full-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+parsing-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+printing-devel = " \
 cargo \
 rust-quote-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+proc-macro-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+test-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+visit-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+visit-mut-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-unicode-ident+default-devel \
 "
