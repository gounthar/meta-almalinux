# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-openpgp"
PV = "2.4.1"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel \
 rust-sequoia-openpgp+compression-bzip2-devel \
 rust-sequoia-openpgp+compression-deflate-devel \
 rust-sequoia-openpgp+compression-devel \
 rust-sequoia-openpgp+crypto-nettle-devel \
 rust-sequoia-openpgp+crypto-openssl-devel \
 rust-sequoia-openpgp+default-devel \
 rust-sequoia-openpgp-devel \
"
PACKAGES:aarch64 = " \
 rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel \
 rust-sequoia-openpgp+compression-bzip2-devel \
 rust-sequoia-openpgp+compression-deflate-devel \
 rust-sequoia-openpgp+compression-devel \
 rust-sequoia-openpgp+crypto-nettle-devel \
 rust-sequoia-openpgp+crypto-openssl-devel \
 rust-sequoia-openpgp+default-devel \
 rust-sequoia-openpgp-devel \
"
PACKAGES:riscv64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-sequoia-openpgp-2.4.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a4c9bbfcf95cf1e14fefbeaa7feeec806d35100e4feac08d2f7a15c7fa78fd7f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel-2.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel.sha256sum] = "6bacc38843b95c355f66c0d44798241bff75b6325d9b048e20dd61e302b9bd99"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+compression-bzip2-devel-2.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+compression-bzip2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+compression-bzip2-devel.sha256sum] = "7783b84e22d7418cf131bbeb2190bf246991ac26b62f0bfa2bd326b1d4f3c774"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+compression-deflate-devel-2.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+compression-deflate-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+compression-deflate-devel.sha256sum] = "94de531e12bf9005e5333005c520d3ddcc2a8880a35970cf1f48eb4374c2f493"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+compression-devel-2.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+compression-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+compression-devel.sha256sum] = "49775dbc737ba19efe63c8ca13ff628115741332f0aad092084bd009bb91b02b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+crypto-nettle-devel-2.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+crypto-nettle-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+crypto-nettle-devel.sha256sum] = "8d720bb8555512241f128a4f79db6854651a12b95e2dea0f1f6f8b37aace21cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+crypto-openssl-devel-2.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+crypto-openssl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+crypto-openssl-devel.sha256sum] = "4ca59d6739be290bc51e659ae8807aa6120e6d873523ae1f8e3ee680a449015c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+default-devel-2.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+default-devel.sha256sum] = "77067753d0b700e6cfb6c0e7961d7ff0e8d0dc6e22605693a79edf09ad36a5ea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp-devel-2.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp-devel.sha256sum] = "46d53b9f5432af4f7511c56fe990b83ed8477c67c6c86c14d0b4f86fa1942711"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel-2.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel.sha256sum] = "8a903c985ccd6ac11184c28b60942842d6a5de44b763a631a6bbd4d6b5b86b98"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+compression-bzip2-devel-2.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+compression-bzip2-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp+compression-bzip2-devel.sha256sum] = "4bc4562006f12cb9c664e0a9de9f914228f4a9a3537466f1e75c89a36a0107ac"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+compression-deflate-devel-2.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+compression-deflate-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp+compression-deflate-devel.sha256sum] = "24f7972e093e1ebf61f92d52dd4dd0e0b1aba20ecaa0b08c098cc65c61e82a6f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+compression-devel-2.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+compression-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp+compression-devel.sha256sum] = "3f0c0e58762cad3a9bb8e3ac641d37d4e245b2ef904a35499c1a22a7b8ab5924"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+crypto-nettle-devel-2.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+crypto-nettle-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp+crypto-nettle-devel.sha256sum] = "4781dfd998911e04f6fb9a00176180b2ee74a58e2909751299634ebd51154e3f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+crypto-openssl-devel-2.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+crypto-openssl-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp+crypto-openssl-devel.sha256sum] = "532c58353ebc62732d36c38807af176cca786c419d00c353b9ec23a86c10c928"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+default-devel-2.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+default-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp+default-devel.sha256sum] = "9580910db33bf9e3cc6faa2c81fb4fc965a27c9289622df5a65a02c2a4218f1e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp-devel-2.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp-devel.sha256sum] = "962a043c176ed5ef64610ef02c01025f4a7ef881ca02e59ccb505adfece26ea5"

RDEPENDS:rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel = " \
 cargo \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+compression-bzip2-devel = " \
 cargo \
 rust-buffered-reader+compression-bzip2-devel \
 rust-bzip2+default-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+compression-deflate-devel = " \
 cargo \
 rust-buffered-reader+compression-deflate-devel \
 rust-flate2+default-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+compression-devel = " \
 cargo \
 rust-sequoia-openpgp+compression-bzip2-devel \
 rust-sequoia-openpgp+compression-deflate-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+crypto-nettle-devel = " \
 cargo \
 rust-nettle+default-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+crypto-openssl-devel = " \
 cargo \
 rust-ctor+default-devel \
 rust-openssl-sys+default-devel \
 rust-ossl+openssl-sys-devel \
 rust-ossl+rfc9580-devel \
 rust-ossl-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+default-devel = " \
 cargo \
 rust-sequoia-openpgp+compression-devel \
 rust-sequoia-openpgp+crypto-nettle-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp-devel = " \
 bash \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-argon2+default-devel \
 rust-base64_0.22+default-devel \
 rust-buffered-reader-devel \
 rust-dyn-clone+default-devel \
 rust-idna+default-devel \
 rust-lalrpop-devel \
 rust-lalrpop-util+default-devel \
 rust-libc+default-devel \
 rust-memsec-devel \
 rust-regex+default-devel \
 rust-regex-syntax+default-devel \
 rust-sha1collisiondetection+std-devel \
 rust-sha1collisiondetection-devel \
 rust-xxhash-rust+default-devel \
 rust-xxhash-rust+xxh3-devel \
 virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~ \
 "
