# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-smallvec"
PV = "1.16.1"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 rust-smallvec+arbitrary-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 rust-smallvec+drain_filter-devel \
 rust-smallvec+drain_keep_rest-devel \
 rust-smallvec+may_dangle-devel \
 rust-smallvec+serde-devel \
 rust-smallvec+specialization-devel \
 rust-smallvec+union-devel \
 rust-smallvec+write-devel \
 rust-smallvec-devel \
"
PACKAGES:aarch64 = " \
 rust-smallvec+arbitrary-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 rust-smallvec+drain_filter-devel \
 rust-smallvec+drain_keep_rest-devel \
 rust-smallvec+may_dangle-devel \
 rust-smallvec+serde-devel \
 rust-smallvec+specialization-devel \
 rust-smallvec+union-devel \
 rust-smallvec+write-devel \
 rust-smallvec-devel \
"
PACKAGES:riscv64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-smallvec-1.16.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1b3e87483b4212cde9ffa3bf575f96e185d9dc17b23dd12a410c20710e69f69a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+arbitrary-devel-1.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+arbitrary-devel.sha256sum] = "9ddfa08a4236de65bb9c52dae7b782b56abb255dddbc7a6139bee06e82da6afa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+const_generics-devel-1.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+const_generics-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+const_generics-devel.sha256sum] = "559fdadf896fb7447e1224a78ac1bad2476d586cd6fa52ad72fff47b1bb8be55"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+const_new-devel-1.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+const_new-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+const_new-devel.sha256sum] = "402464861ccbe2f86c666f4ca269149aa755dd091b2eb86da7e388637c4465de"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+default-devel-1.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+default-devel.sha256sum] = "7c923007739d57185d588e143382b9abdc78e5fdff1f6ea792f34f7b35cbf13f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+drain_filter-devel-1.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+drain_filter-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+drain_filter-devel.sha256sum] = "d4854a061f2a1e11f31de3f5d57db5eca5d9e58a1052cfe3c06671dcb55d9bb1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+drain_keep_rest-devel-1.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+drain_keep_rest-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+drain_keep_rest-devel.sha256sum] = "f7c126ea04e890ce2a8cee2bcc28dcb45d4f1a433efe14d67b7e06b79cf11f5e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+may_dangle-devel-1.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+may_dangle-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+may_dangle-devel.sha256sum] = "f41fa69ec4e41659696d25b9ca4025160e4a1c1ac74e643603c69c180165e453"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+serde-devel-1.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+serde-devel.sha256sum] = "7a1ba0c9e5388f698ca3d248fbd041260019b6df128ff380466013a383a0981b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+specialization-devel-1.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+specialization-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+specialization-devel.sha256sum] = "1d3c2850679a9170a667151533ff62b7bc9e01c3f06471f322dd551920274cf3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+union-devel-1.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+union-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+union-devel.sha256sum] = "0a833fbbd51fc5f542e02337df5d8232edc9ad129afdd20000818fc648eec8ea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+write-devel-1.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+write-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+write-devel.sha256sum] = "ded7fdb355b40bc57be77314c1e6136dd4598a811c498c64fa0100db5465ca7d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec-devel-1.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec-devel.sha256sum] = "253736cc207debbfa00fe6614a5db63cb7360b8a613048c45403a83cde64a006"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+arbitrary-devel-1.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+arbitrary-devel.sha256sum] = "bc64b16d3a2c384491c03994b3aca20e087bd6234bff2f99f5ae7c95bef36c4d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+const_generics-devel-1.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+const_generics-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+const_generics-devel.sha256sum] = "d25a5a12e203b53d1ab4617533c64a8fded593a7cd2f3fe387540a1f7c9a9099"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+const_new-devel-1.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+const_new-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+const_new-devel.sha256sum] = "92318783e628eb891c46fa326dd1a1b326fd320554973f6e4b58382166ea0693"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+default-devel-1.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+default-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+default-devel.sha256sum] = "5f86c3bc0fdd69dc97eda35d12009161062b0cd065ea0f895fc2663afa9091c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+drain_filter-devel-1.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+drain_filter-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+drain_filter-devel.sha256sum] = "893ed990b3a98face8658599e520c21fd3f849931c1b0a209afd58d10404743f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+drain_keep_rest-devel-1.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+drain_keep_rest-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+drain_keep_rest-devel.sha256sum] = "794291bfe2e3f6331ac7b1b3032da459acbd9e3206c14d3d8de047db8c010fc5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+may_dangle-devel-1.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+may_dangle-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+may_dangle-devel.sha256sum] = "6b50fb5c3fc12ae2e33a0aa0853e81a50455abde34ce21745213b18bf932c9c0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+serde-devel-1.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+serde-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+serde-devel.sha256sum] = "3b14051b28a06718211d1c896837a26bdc8321c934dc83d896e5033bd2e7b4cb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+specialization-devel-1.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+specialization-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+specialization-devel.sha256sum] = "2e215b863c057cb5c1416b55771a7c120d307ce7f55d1678a1a62bfa6fd3b64f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+union-devel-1.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+union-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+union-devel.sha256sum] = "6df9ae162f6fc5ae6d1389e5fcb6c74913076d7d71007c4867f2b0ecb2ae3c98"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+write-devel-1.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+write-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+write-devel.sha256sum] = "b08e92c2266265a534193492609c4e4b4ad9bc123be8863e6a6792933d182449"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec-devel-1.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec-devel.sha256sum] = "1b54a5b4589e1be6973d40647102baab64befafd3aaa87f7f824437103f7afd9"

RDEPENDS:rust-smallvec+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+const_generics-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+const_new-devel = " \
 cargo \
 rust-smallvec+const_generics-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+default-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+drain_filter-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+drain_keep_rest-devel = " \
 cargo \
 rust-smallvec+drain_filter-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+may_dangle-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+specialization-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+union-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+write-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec-devel = " \
 cargo \
 "
