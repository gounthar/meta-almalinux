# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-find-msvc-tools"
PV = "0.1.12"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 rust-find-msvc-tools+default-devel \
 rust-find-msvc-tools-devel \
"
PACKAGES:aarch64 = " \
 rust-find-msvc-tools+default-devel \
 rust-find-msvc-tools-devel \
"
PACKAGES:riscv64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-find-msvc-tools-0.1.12-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b51484bfaf920cbfa756565762993538ce5f06b4cd8de435a58b5383b96e3114"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-msvc-tools+default-devel-0.1.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-msvc-tools+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-find-msvc-tools+default-devel.sha256sum] = "935b87e6ba1265261e443b36ab65bf713a998377cb179de7bfa65d54d3bd63ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-msvc-tools-devel-0.1.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-msvc-tools-devel;unpack=0"
SRC_URI[x86_64_v2_rust-find-msvc-tools-devel.sha256sum] = "592631a6afb0f3e6de6440a22e3d6647d8986bf6a1ba54266da0e00c2f7aaf58"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-find-msvc-tools+default-devel-0.1.12-1.el10_3.noarch.rpm;name=aarch64_rust-find-msvc-tools+default-devel;unpack=0"
SRC_URI[aarch64_rust-find-msvc-tools+default-devel.sha256sum] = "405d0008f3ea60da767936c3503f39123b2241ec38fafde75fe92f7bb3fe7b6c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-find-msvc-tools-devel-0.1.12-1.el10_3.noarch.rpm;name=aarch64_rust-find-msvc-tools-devel;unpack=0"
SRC_URI[aarch64_rust-find-msvc-tools-devel.sha256sum] = "64d5295146a7bf08a35a49d0d218ece961252c8101190733cb85fb0fbd73bf44"

RDEPENDS:rust-find-msvc-tools+default-devel = " \
 cargo \
 rust-find-msvc-tools-devel \
 "
RDEPENDS:rust-find-msvc-tools-devel = " \
 cargo \
 rust \
 "
