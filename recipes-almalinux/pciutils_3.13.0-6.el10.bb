# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pciutils"
PV = "3.13.0"
PR = "6.el10"
PACKAGES = " \
 pciutils \
 pciutils-devel \
 pciutils-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/pciutils-3.13.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5b0c9c48cf015aff0c43292a3d23f462c71ce0783064f3cd90ba0cd58217b990"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pciutils-3.13.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_pciutils;unpack=0"
SRC_URI[x86_64_v2_pciutils.sha256sum] = "47284a5099a468b7927d032c9dccd1009e435b37623949c6afbb967dd9040d35"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pciutils-devel-3.13.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_pciutils-devel;unpack=0"
SRC_URI[x86_64_v2_pciutils-devel.sha256sum] = "cca6506702da408add8f114f0476a296ab59c7c38f75bacbaa486adc40d7f6d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pciutils-libs-3.13.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_pciutils-libs;unpack=0"
SRC_URI[x86_64_v2_pciutils-libs.sha256sum] = "d6b391e12193e213a05d9956ceca3e49f30ff797e122c8efde411e8f31d0b7b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pciutils-3.13.0-6.el10.aarch64.rpm;name=aarch64_pciutils;unpack=0"
SRC_URI[aarch64_pciutils.sha256sum] = "0a29cf96bd4980ee14bd8bb10940813af5c946488f3e50a553bea2d92018cf5a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pciutils-devel-3.13.0-6.el10.aarch64.rpm;name=aarch64_pciutils-devel;unpack=0"
SRC_URI[aarch64_pciutils-devel.sha256sum] = "d05e847d78563c142e8ac727ab72e281b44a4d6021c1d8b891ed1549284918e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pciutils-libs-3.13.0-6.el10.aarch64.rpm;name=aarch64_pciutils-libs;unpack=0"
SRC_URI[aarch64_pciutils-libs.sha256sum] = "92c5c60d11de978305fff96df6b5042b983231d9a29120ab89287d2df5b2354d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/pciutils-3.13.0-6.el10.riscv64.rpm;name=riscv64_pciutils;unpack=0"
SRC_URI[riscv64_pciutils.sha256sum] = "47816707a9e555d1d88a1391106013957238058b0b2a1cb777c843379c0d056d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/pciutils-devel-3.13.0-6.el10.riscv64.rpm;name=riscv64_pciutils-devel;unpack=0"
SRC_URI[riscv64_pciutils-devel.sha256sum] = "859f1fca38b1c18ebf650551932b4c8d9b36fd99147a4becd9e260c028081e16"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/pciutils-libs-3.13.0-6.el10.riscv64.rpm;name=riscv64_pciutils-libs;unpack=0"
SRC_URI[riscv64_pciutils-libs.sha256sum] = "14d5c225c0dfc92eff35701cef26b7482ab109f55b13c35ff96b57e1c31a12d2"

RDEPENDS:pciutils = " \
 bash \
 glibc \
 hwdata \
 kmod-libs \
 pciutils-libs \
 "
RDEPENDS:pciutils-devel = " \
 pciutils \
 pciutils-libs \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:pciutils-libs = " \
 glibc \
 "
