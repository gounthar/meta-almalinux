# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "traceroute"
PE = "3"
PV = "2.1.6"
PR = "3.el10"
PACKAGES = " \
 traceroute \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/traceroute-2.1.6-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "744eecdb6f47df5731213194decff03e1eb2f22a533ccde82432584a4d5f23eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/traceroute-2.1.6-3.el10.x86_64_v2.rpm;name=x86_64_v2_traceroute;unpack=0"
SRC_URI[x86_64_v2_traceroute.sha256sum] = "5a8235941be33ac7dc1734bdcef4095ad5a6483d6e3eff91c5a532fda679b7e8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/traceroute-2.1.6-3.el10.aarch64.rpm;name=aarch64_traceroute;unpack=0"
SRC_URI[aarch64_traceroute.sha256sum] = "f19dd8ab482a974a4024786668500bb39df889727cbcb72b4b23baaedccc8203"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/traceroute-2.1.6-3.el10.riscv64.rpm;name=riscv64_traceroute;unpack=0"
SRC_URI[riscv64_traceroute.sha256sum] = "72a5163cb4228de5d5f63ee1fc40096797445bc19c4584c918c99c0ad16db8ee"

RDEPENDS:traceroute = " \
 bash \
 glibc \
 "
