# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ibus-libzhuyin"
PV = "1.10.3"
PR = "3.el10"
PACKAGES = " \
 ibus-libzhuyin \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ibus-libzhuyin-1.10.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e7bd44b4ebb3feda7e8700beda76eae6b22cfed9b2773ad36c7f455e0ce770a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-libzhuyin-1.10.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-libzhuyin;unpack=0"
SRC_URI[x86_64_v2_ibus-libzhuyin.sha256sum] = "6724db3b581b30418038cb4d4d135af05c9cb9ee56642877905aea4afb572c7b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-libzhuyin-1.10.3-3.el10.aarch64.rpm;name=aarch64_ibus-libzhuyin;unpack=0"
SRC_URI[aarch64_ibus-libzhuyin.sha256sum] = "d7b87089a8563adafe421dc697f2556c639a2c6f31182af226c99e85ca2b4e14"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/ibus-libzhuyin-1.10.3-3.el10.riscv64.rpm;name=riscv64_ibus-libzhuyin;unpack=0"
SRC_URI[riscv64_ibus-libzhuyin.sha256sum] = "290887e6facd78267601cb824682889cbb8bea719b587c3311e211e931bd2186"

RDEPENDS:ibus-libzhuyin = " \
 bash \
 glib2 \
 glibc \
 ibus \
 ibus-libs \
 libgcc \
 libstdc++ \
 libzhuyin \
 "
