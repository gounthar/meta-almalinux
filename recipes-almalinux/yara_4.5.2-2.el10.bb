# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yara"
PV = "4.5.2"
PR = "2.el10"
PACKAGES = " \
 yara \
 yara-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/yara-4.5.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "85768e0f243ceb078acddde33ff21ce763b936c3c257b92549673186e94548a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/yara-4.5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_yara;unpack=0"
SRC_URI[x86_64_v2_yara.sha256sum] = "cd0546e52b8f09db556fc1ce2ddcb6f7eb14a155aaa43badb87d498134580b11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/yara-devel-4.5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_yara-devel;unpack=0"
SRC_URI[x86_64_v2_yara-devel.sha256sum] = "283e7ca086569dc4ff02828b34904190cbcc1a026cac9d6c5cd02e2b7ba902ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/yara-4.5.2-2.el10.aarch64.rpm;name=aarch64_yara;unpack=0"
SRC_URI[aarch64_yara.sha256sum] = "93d2a08999a8885f11dcb27d42f249b5af11cab9b7a1f074a4300a5c2ab78fcb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/yara-devel-4.5.2-2.el10.aarch64.rpm;name=aarch64_yara-devel;unpack=0"
SRC_URI[aarch64_yara-devel.sha256sum] = "c8f5de03d1a87b04ea1c055a0c079f2df879851199c79476a64b1d2c13f21bde"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/yara-4.5.2-2.el10.riscv64.rpm;name=riscv64_yara;unpack=0"
SRC_URI[riscv64_yara.sha256sum] = "67fe10d975326732358a22b5ce90fb91d18460420db436b341b4413743a29f09"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/yara-devel-4.5.2-2.el10.riscv64.rpm;name=riscv64_yara-devel;unpack=0"
SRC_URI[riscv64_yara-devel.sha256sum] = "11ca21a850bf0e6ad503ec0b35911d7bff1d097ba1a16939cc7fda8e56c5515b"

RDEPENDS:yara = " \
 file-libs \
 glibc \
 jansson \
 openssl-libs \
 protobuf-c \
 "
RDEPENDS:yara-devel = " \
 jansson-devel \
 openssl-devel \
 pkgconf-pkg-config \
 protobuf-c-devel \
 yara \
 "
