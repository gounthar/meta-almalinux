# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crypto-auditing-agent"
PV = "0.3.2"
PR = "1.el10"
PACKAGES = " \
 crypto-auditing-agent \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-crypto-auditing-agent-0.3.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0ad6e260083a1e9663a4e3adb671b69d419c19501309a99f0c512718680a87a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crypto-auditing-agent-0.3.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_crypto-auditing-agent;unpack=0"
SRC_URI[x86_64_v2_crypto-auditing-agent.sha256sum] = "4e566c95280cdb231f068d3d29262faa6efd0ee5109819c2bb48b5a10966d2b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crypto-auditing-agent-0.3.2-1.el10.aarch64.rpm;name=aarch64_crypto-auditing-agent;unpack=0"
SRC_URI[aarch64_crypto-auditing-agent.sha256sum] = "7b22df9516999f43c35a0af4b2d867024beb9b790bb60014501338d310d05560"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/crypto-auditing-agent-0.3.2-1.el10.riscv64.rpm;name=riscv64_crypto-auditing-agent;unpack=0"
SRC_URI[riscv64_crypto-auditing-agent.sha256sum] = "63e9c9a5411101a01d4732841828aeb7aed90c59140faa12dfcbe5f99d52f24a"

RDEPENDS:crypto-auditing-agent = " \
 bash \
 glibc \
 libbpf \
 libgcc \
 openssl-libs \
 "
