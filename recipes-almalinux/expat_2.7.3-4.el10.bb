# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "expat"
PV = "2.7.3"
PR = "4.el10"
PACKAGES = " \
 expat \
 expat-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/expat-2.7.3-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8ba5ace85ecec351a270ca66912ff7df6a040aa4171e937589f8b234f9e7f6f7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/expat-2.7.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_expat;unpack=0"
SRC_URI[x86_64_v2_expat.sha256sum] = "ebcf519a79a096dc0d731ecaf922b93ad8e5e8c5eaaa567b02be9d900d9d1359"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/expat-devel-2.7.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_expat-devel;unpack=0"
SRC_URI[x86_64_v2_expat-devel.sha256sum] = "fa4ad6c7fa23c577e63607863b7141f639da1fbdb4bd555b786246310ccf088a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/expat-2.7.3-4.el10.aarch64.rpm;name=aarch64_expat;unpack=0"
SRC_URI[aarch64_expat.sha256sum] = "c5a0fbeafa3de92288f312af25979f4870cb10a513478d5dd29029ce5c143f5f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/expat-devel-2.7.3-4.el10.aarch64.rpm;name=aarch64_expat-devel;unpack=0"
SRC_URI[aarch64_expat-devel.sha256sum] = "f2f7c047c6fdae573804c9afc984547cf68bf23fdfb2b65aa732091734ba451c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/expat-2.7.3-4.el10.riscv64.rpm;name=riscv64_expat;unpack=0"
SRC_URI[riscv64_expat.sha256sum] = "aae08b4b638e4c21161f4a378fc9e158520c6db24a96ff096ee402d8da4994f5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/expat-devel-2.7.3-4.el10.riscv64.rpm;name=riscv64_expat-devel;unpack=0"
SRC_URI[riscv64_expat-devel.sha256sum] = "725202f8399360c549c6faac4c0df006110f10cf0ccf54472b906c3758d3e909"

RDEPENDS:expat = " \
 glibc \
 "
RDEPENDS:expat-devel = " \
 expat \
 pkgconf-pkg-config \
 "
