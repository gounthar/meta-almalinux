# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fido-device-onboard"
PV = "0.5.6"
PR = "1.el10"
PACKAGES = " \
 fdo-admin-cli \
 fdo-client \
 fdo-init \
 fdo-manufacturing-server \
 fdo-owner-cli \
 fdo-owner-onboarding-server \
 fdo-rendezvous-server \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fido-device-onboard-0.5.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6a6fb937c0dc1af2e1759c3b2d66da4fa2ec5f44428b620a854eda859e566112"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-admin-cli-0.5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_fdo-admin-cli;unpack=0"
SRC_URI[x86_64_v2_fdo-admin-cli.sha256sum] = "ce1ad98cf67d5f839c3ed9c9200eebf56d855497b257d021385935b459d43c73"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-client-0.5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_fdo-client;unpack=0"
SRC_URI[x86_64_v2_fdo-client.sha256sum] = "469de73fdfcadd0e3c6cc68b313c5a34ab4c09f775cad043f59c591a6c327108"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-init-0.5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_fdo-init;unpack=0"
SRC_URI[x86_64_v2_fdo-init.sha256sum] = "5413b6318e5f55aac53fdcac5b77dbc669e63a02c3559fa40bb6a0282d47a912"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-manufacturing-server-0.5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_fdo-manufacturing-server;unpack=0"
SRC_URI[x86_64_v2_fdo-manufacturing-server.sha256sum] = "9fc7cc45b0cc345aa05dc0ceb358c44ae2739d8006255fd4871b38bcf923714a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-owner-cli-0.5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_fdo-owner-cli;unpack=0"
SRC_URI[x86_64_v2_fdo-owner-cli.sha256sum] = "63358081b3a8b04932185cbe7ebd8838442ef44846980c482f8cf669b0b1d52a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-owner-onboarding-server-0.5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_fdo-owner-onboarding-server;unpack=0"
SRC_URI[x86_64_v2_fdo-owner-onboarding-server.sha256sum] = "bb055b54f0f3fc952ad314c59e77a2e9f9f828bef7b141ad0393f3230056232d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-rendezvous-server-0.5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_fdo-rendezvous-server;unpack=0"
SRC_URI[x86_64_v2_fdo-rendezvous-server.sha256sum] = "e483ce2ae3de11a5830f40cee3d7ae48168d8e947c50db3edbd06d2e7c1ff367"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fdo-admin-cli-0.5.6-1.el10.aarch64.rpm;name=aarch64_fdo-admin-cli;unpack=0"
SRC_URI[aarch64_fdo-admin-cli.sha256sum] = "91fb04e2c6cdfe63425896d8d3e0974a1424147535c2858a328dcfad3bc5b5c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fdo-client-0.5.6-1.el10.aarch64.rpm;name=aarch64_fdo-client;unpack=0"
SRC_URI[aarch64_fdo-client.sha256sum] = "4589ab1252340b6d734a7ddfca70f5c48013707811f59a607ce5f537190c234d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fdo-init-0.5.6-1.el10.aarch64.rpm;name=aarch64_fdo-init;unpack=0"
SRC_URI[aarch64_fdo-init.sha256sum] = "4a5bd2460aec585b60c5ba3ea3cbe4ead8abe18a77ebed7a46a6589b91e47979"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fdo-manufacturing-server-0.5.6-1.el10.aarch64.rpm;name=aarch64_fdo-manufacturing-server;unpack=0"
SRC_URI[aarch64_fdo-manufacturing-server.sha256sum] = "b40a49ca79d3e6aed89d4012b82494894cfad1eaf752e1358c460eae1f1c819e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fdo-owner-cli-0.5.6-1.el10.aarch64.rpm;name=aarch64_fdo-owner-cli;unpack=0"
SRC_URI[aarch64_fdo-owner-cli.sha256sum] = "cf823160a21d0ec9ace02f8bc4fd4a0be768dbcb79866acc0b456930776b8c35"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fdo-owner-onboarding-server-0.5.6-1.el10.aarch64.rpm;name=aarch64_fdo-owner-onboarding-server;unpack=0"
SRC_URI[aarch64_fdo-owner-onboarding-server.sha256sum] = "b3438a35e422336a623c0d7e9e85010190f974108a9d58a931c881e2b6643374"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fdo-rendezvous-server-0.5.6-1.el10.aarch64.rpm;name=aarch64_fdo-rendezvous-server;unpack=0"
SRC_URI[aarch64_fdo-rendezvous-server.sha256sum] = "08118275d67f523d3c6ec07a33b7617d7d8a4ce20ecfc4dce6971d48ca6eb328"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/fdo-admin-cli-0.5.6-1.el10.riscv64.rpm;name=riscv64_fdo-admin-cli;unpack=0"
SRC_URI[riscv64_fdo-admin-cli.sha256sum] = "7378c361e34fc4cc89f2bbbb63cdfabf9a4382b5e4cd93c8e0c360888e991a60"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/fdo-client-0.5.6-1.el10.riscv64.rpm;name=riscv64_fdo-client;unpack=0"
SRC_URI[riscv64_fdo-client.sha256sum] = "2a2af6edf378467e87e2aac9046059d3ef83b46bf1df4b2757c4b240b320f454"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/fdo-init-0.5.6-1.el10.riscv64.rpm;name=riscv64_fdo-init;unpack=0"
SRC_URI[riscv64_fdo-init.sha256sum] = "e76999b3afc6c61dcbd3ec0c1f35de10f56a8d9d6974882a34d0ffed577e1a70"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/fdo-manufacturing-server-0.5.6-1.el10.riscv64.rpm;name=riscv64_fdo-manufacturing-server;unpack=0"
SRC_URI[riscv64_fdo-manufacturing-server.sha256sum] = "ad57162528af3e3f83cf33ac3d3b1fcff5ed547ffe29eec822bd7e6209c8a7c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/fdo-owner-cli-0.5.6-1.el10.riscv64.rpm;name=riscv64_fdo-owner-cli;unpack=0"
SRC_URI[riscv64_fdo-owner-cli.sha256sum] = "11ba85984785cec4170ad3cc0e3e6f3b0d8aaf1bc851e8dd7ec912efc691b086"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/fdo-owner-onboarding-server-0.5.6-1.el10.riscv64.rpm;name=riscv64_fdo-owner-onboarding-server;unpack=0"
SRC_URI[riscv64_fdo-owner-onboarding-server.sha256sum] = "27089cb8f7e5f366b05ebf7fea7e841ebfbbdcb48a94a9acfb4420740290094e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/fdo-rendezvous-server-0.5.6-1.el10.riscv64.rpm;name=riscv64_fdo-rendezvous-server;unpack=0"
SRC_URI[riscv64_fdo-rendezvous-server.sha256sum] = "89e5987041da2e7cbf613f4954da1a8a07c991d5113b98f5985504ce3ab29a6f"

RDEPENDS:fdo-admin-cli = " \
 bash \
 fdo-client \
 fdo-init \
 fdo-manufacturing-server \
 fdo-owner-cli \
 fdo-owner-onboarding-server \
 fdo-rendezvous-server \
 glibc \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-client = " \
 bash \
 clevis \
 clevis-luks \
 clevis-pin-tpm2 \
 cryptsetup \
 cryptsetup-libs \
 glibc \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-init = " \
 bash \
 dracut \
 glibc \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-manufacturing-server = " \
 bash \
 glibc \
 libgcc \
 libpq \
 openssl-libs \
 sqlite-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-owner-cli = " \
 glibc \
 libgcc \
 libpq \
 openssl-libs \
 sqlite-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-owner-onboarding-server = " \
 bash \
 glibc \
 libgcc \
 libpq \
 openssl-libs \
 sqlite-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-rendezvous-server = " \
 bash \
 glibc \
 libgcc \
 libpq \
 openssl-libs \
 sqlite-libs \
 tpm2-tss \
 "
