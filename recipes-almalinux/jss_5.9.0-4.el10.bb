# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jss"
PV = "5.9.0"
PR = "4.el10"
PACKAGES = " \
 idm-jss \
 idm-jss-tomcat \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jss-5.9.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4628f8f1b22d553858d1d9fb0bce5ed33cbb37cd131f5fd2ed5fdb143058c62c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-jss-5.9.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_idm-jss;unpack=0"
SRC_URI[x86_64_v2_idm-jss.sha256sum] = "356bb892daed949293322458d9a7f0dfbf08f7b2e33cf04a2b4cb79321a8783d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-jss-tomcat-5.9.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_idm-jss-tomcat;unpack=0"
SRC_URI[x86_64_v2_idm-jss-tomcat.sha256sum] = "e0e6fd535b3fced8b801f3a2e9d918e4b3befed5b725d01d755110a9076951b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-jss-5.9.0-4.el10.aarch64.rpm;name=aarch64_idm-jss;unpack=0"
SRC_URI[aarch64_idm-jss.sha256sum] = "ae65d2b5a4596bdf6846c2296a7eea5db0d03a8da0dbd0280ca051d7895eecee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-jss-tomcat-5.9.0-4.el10.aarch64.rpm;name=aarch64_idm-jss-tomcat;unpack=0"
SRC_URI[aarch64_idm-jss-tomcat.sha256sum] = "be8df0d1f8c74e83246b4d3c10041193b4e8c6a0116ab1f0bf9d157f1ed4abe6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/idm-jss-5.9.0-4.el10.riscv64.rpm;name=riscv64_idm-jss;unpack=0"
SRC_URI[riscv64_idm-jss.sha256sum] = "dad3c593b5b25df0faea742ade4e3fd497af798b1f80114a037392e684c8f2ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/idm-jss-tomcat-5.9.0-4.el10.riscv64.rpm;name=riscv64_idm-jss-tomcat;unpack=0"
SRC_URI[riscv64_idm-jss-tomcat.sha256sum] = "5db4c99c71360d68edfebf8c78abc8e40383f714bbce47e56ef4873f8695bab7"

RDEPENDS:idm-jss = " \
 apache-commons-lang3 \
 glibc \
 java-21-openjdk-headless \
 javapackages-filesystem \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 slf4j \
 slf4j-jdk14 \
 "
RDEPENDS:idm-jss-tomcat = " \
 idm-jss \
 javapackages-filesystem \
 tomcat-lib \
 virtual/mvn_org.apache.tomcat_tomcat-catalina_ \
 virtual/mvn_org.apache.tomcat_tomcat-coyote_ \
 virtual/mvn_org.apache.tomcat_tomcat-juli_ \
 "
