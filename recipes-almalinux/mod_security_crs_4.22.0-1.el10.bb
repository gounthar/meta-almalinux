# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_security_crs"
PV = "4.22.0"
PR = "1.el10"
PACKAGES = " \
 mod_security_crs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_security_crs-4.22.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "191b894f3eb7587a99eaec46ed6f0930578b0b477c0289d70b0c4830f7d7cf0a"

## Requires (riscv64) that were seen as not satisfiable in original repo:
# - mod_security_crs: mod_security >= 2.9.6

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_security_crs-4.22.0-1.el10.noarch.rpm;name=x86_64_v2_mod_security_crs;unpack=0"
SRC_URI[x86_64_v2_mod_security_crs.sha256sum] = "cadb763c1783028c821ddda0053a63a76bc6236b7811b4460d93fa467a716781"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_security_crs-4.22.0-1.el10.noarch.rpm;name=aarch64_mod_security_crs;unpack=0"
SRC_URI[aarch64_mod_security_crs.sha256sum] = "cadb763c1783028c821ddda0053a63a76bc6236b7811b4460d93fa467a716781"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/mod_security_crs-4.22.0-1.el10.noarch.rpm;name=riscv64_mod_security_crs;unpack=0"
SRC_URI[riscv64_mod_security_crs.sha256sum] = "cadb763c1783028c821ddda0053a63a76bc6236b7811b4460d93fa467a716781"

RDEPENDS:mod_security_crs:x86_64_v2 = " \
 bash \
 mod_security \
"
RDEPENDS:mod_security_crs:aarch64 = " \
 bash \
 mod_security \
"
RDEPENDS:mod_security_crs:riscv64 = " \
 bash \
"
