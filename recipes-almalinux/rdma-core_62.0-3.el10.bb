# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rdma-core"
PV = "62.0"
PR = "3.el10"
PACKAGES = " \
 ibacm \
 infiniband-diags \
 iwpmd \
 libibumad \
 libibverbs \
 libibverbs-utils \
 librdmacm \
 librdmacm-utils \
 python3-pyverbs \
 rdma-core \
 rdma-core-devel \
 srp_daemon \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rdma-core-62.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e9c754c788513d583521fc4e3ae5a79964af6475e9fff75dd2f1e129a4642d44"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ibacm-62.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_ibacm;unpack=0"
SRC_URI[x86_64_v2_ibacm.sha256sum] = "3d39abe1bfe885a2c1091626154295ebcfe678b9d01a017d81da5db8efbecf4f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/infiniband-diags-62.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_infiniband-diags;unpack=0"
SRC_URI[x86_64_v2_infiniband-diags.sha256sum] = "993752a3266dd415e25eea5176afea945861bbdba2a511132bd80bc45996f5bf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwpmd-62.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_iwpmd;unpack=0"
SRC_URI[x86_64_v2_iwpmd.sha256sum] = "52c57fb90690e83791e23a39ddd9ca5bd009cafb7b27fbe6ff0c169f0e701a50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libibumad-62.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libibumad;unpack=0"
SRC_URI[x86_64_v2_libibumad.sha256sum] = "77c893d6c062d961db1848a11194771849d523762d502ba9281791bcb2bb3742"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libibverbs-62.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libibverbs;unpack=0"
SRC_URI[x86_64_v2_libibverbs.sha256sum] = "b5970870165eeb7f33b199d850d3ef3dbe825a35d4dd396f63daee437d4056be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libibverbs-utils-62.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libibverbs-utils;unpack=0"
SRC_URI[x86_64_v2_libibverbs-utils.sha256sum] = "2335971811d9872f2b64b75d904dd38952e16bc479ab44bd8295c654cfdd854f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/librdmacm-62.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_librdmacm;unpack=0"
SRC_URI[x86_64_v2_librdmacm.sha256sum] = "15ef83e36c8057aa800883d2070be0c28aa7cab2c6695f1919ac2c13bd6c6374"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/librdmacm-utils-62.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_librdmacm-utils;unpack=0"
SRC_URI[x86_64_v2_librdmacm-utils.sha256sum] = "362a0e21cced6a5c62fa806e34065e78df1986b5d84b7bc7ef77c4bc44f078d6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyverbs-62.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pyverbs;unpack=0"
SRC_URI[x86_64_v2_python3-pyverbs.sha256sum] = "25b3e2cf244430da8befb3a7684d72b269e45bfcdf2dc3565bc05a294131bbe4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rdma-core-62.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_rdma-core;unpack=0"
SRC_URI[x86_64_v2_rdma-core.sha256sum] = "c9bcbabd30964322e25f969be519785943801cf54d8755312ecef21d159b0e03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rdma-core-devel-62.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_rdma-core-devel;unpack=0"
SRC_URI[x86_64_v2_rdma-core-devel.sha256sum] = "457de2b1b7b24f115b8d069028f7378b635b737df725c14fe0861a23cbb6a60e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/srp_daemon-62.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_srp_daemon;unpack=0"
SRC_URI[x86_64_v2_srp_daemon.sha256sum] = "eef43222114e254908d026f6dfc7d1d89a206e32240dca788c76ed26dbbff154"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ibacm-62.0-3.el10.aarch64.rpm;name=aarch64_ibacm;unpack=0"
SRC_URI[aarch64_ibacm.sha256sum] = "d8ba7f65cde9e2aca60ff988cf5f1f2b971b0657d7b1eea1d15079da27c11067"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/infiniband-diags-62.0-3.el10.aarch64.rpm;name=aarch64_infiniband-diags;unpack=0"
SRC_URI[aarch64_infiniband-diags.sha256sum] = "31c3559c451835767e8fbb6eb45ce5e45e56d76d616855b8893165c1702c1813"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwpmd-62.0-3.el10.aarch64.rpm;name=aarch64_iwpmd;unpack=0"
SRC_URI[aarch64_iwpmd.sha256sum] = "dd93c01f72c0411381c69afd26b5f4e60b82127d578bbb099b0878a5baef340b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libibumad-62.0-3.el10.aarch64.rpm;name=aarch64_libibumad;unpack=0"
SRC_URI[aarch64_libibumad.sha256sum] = "43abf68d6df0b09f5d197c74cabadd8bf2267f037ed753b64e41e6184e9a5e60"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libibverbs-62.0-3.el10.aarch64.rpm;name=aarch64_libibverbs;unpack=0"
SRC_URI[aarch64_libibverbs.sha256sum] = "63032fbd97842edee69eb1b698b63afdd5950c84bb757a2d429e58635f27a565"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libibverbs-utils-62.0-3.el10.aarch64.rpm;name=aarch64_libibverbs-utils;unpack=0"
SRC_URI[aarch64_libibverbs-utils.sha256sum] = "31f8cd52356f2e4545306f8a8b5c8eea0e816a209b2d60744a351b74d1e622ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/librdmacm-62.0-3.el10.aarch64.rpm;name=aarch64_librdmacm;unpack=0"
SRC_URI[aarch64_librdmacm.sha256sum] = "eed995689c8770a1eecde53767e56f1038d9a4ef980a1cf0ebe8dc2e1cdd1623"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/librdmacm-utils-62.0-3.el10.aarch64.rpm;name=aarch64_librdmacm-utils;unpack=0"
SRC_URI[aarch64_librdmacm-utils.sha256sum] = "99c4e72e34722eb288ff9b31fed02740b5bf7e897a2d3476b10a9f1d9278fd4a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyverbs-62.0-3.el10.aarch64.rpm;name=aarch64_python3-pyverbs;unpack=0"
SRC_URI[aarch64_python3-pyverbs.sha256sum] = "218a24b7b99f6629b48ba4f0b2a152f4ae605e1fcb348265b7ea2b93be8ec9d9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rdma-core-62.0-3.el10.aarch64.rpm;name=aarch64_rdma-core;unpack=0"
SRC_URI[aarch64_rdma-core.sha256sum] = "de03395e4c129969d95dfeb8688a9e2784afa44a48ce4afdd0012f489403bb02"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rdma-core-devel-62.0-3.el10.aarch64.rpm;name=aarch64_rdma-core-devel;unpack=0"
SRC_URI[aarch64_rdma-core-devel.sha256sum] = "8c2be777a4508624a3fcc6198815d1bfeacbd67a1c2f8ea34ce5d710301eec07"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/srp_daemon-62.0-3.el10.aarch64.rpm;name=aarch64_srp_daemon;unpack=0"
SRC_URI[aarch64_srp_daemon.sha256sum] = "4e7090263d08f9d05554fef8bb3274fd4b1c82f55bdf0eff2fb50a033ee133a9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/ibacm-62.0-3.el10.riscv64.rpm;name=riscv64_ibacm;unpack=0"
SRC_URI[riscv64_ibacm.sha256sum] = "c07fc3ba74f4f546b8ae7d33439a9158173d5cdd2acf441f59030c021e2ce7eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/infiniband-diags-62.0-3.el10.riscv64.rpm;name=riscv64_infiniband-diags;unpack=0"
SRC_URI[riscv64_infiniband-diags.sha256sum] = "af67e89ad4aaf5239cdd9134b807c95ee354643b73cd45b346da395d797c8a03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/iwpmd-62.0-3.el10.riscv64.rpm;name=riscv64_iwpmd;unpack=0"
SRC_URI[riscv64_iwpmd.sha256sum] = "53c6ff2577c2f40703e61173d491c9c290a1652e100c6d13dd165238f6fac52a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libibumad-62.0-3.el10.riscv64.rpm;name=riscv64_libibumad;unpack=0"
SRC_URI[riscv64_libibumad.sha256sum] = "bc6fcedef27f8d4faa936340e9c882e1c79f46fa05833df8854d6ee4a4c1d91b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libibverbs-62.0-3.el10.riscv64.rpm;name=riscv64_libibverbs;unpack=0"
SRC_URI[riscv64_libibverbs.sha256sum] = "7196dcd5b1de0cc24e4ed7bc7bfcdaeff1d3f4834af494cd5c6b3b022bf08f06"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libibverbs-utils-62.0-3.el10.riscv64.rpm;name=riscv64_libibverbs-utils;unpack=0"
SRC_URI[riscv64_libibverbs-utils.sha256sum] = "56bd8207f5b5603d3e3da02841e637b36af605a6bfe6b02dc9c8d85b6aefdd88"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/librdmacm-62.0-3.el10.riscv64.rpm;name=riscv64_librdmacm;unpack=0"
SRC_URI[riscv64_librdmacm.sha256sum] = "0ebcecc3e62885c21a9c7715f6819b147cf658391d3c297f4b5f272e7bcf55d8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/librdmacm-utils-62.0-3.el10.riscv64.rpm;name=riscv64_librdmacm-utils;unpack=0"
SRC_URI[riscv64_librdmacm-utils.sha256sum] = "d30ef59f100fba5da03ab280010732e180f3b272eee5e929bd14ad69b9ac4ebc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/python3-pyverbs-62.0-3.el10.riscv64.rpm;name=riscv64_python3-pyverbs;unpack=0"
SRC_URI[riscv64_python3-pyverbs.sha256sum] = "3a5a8ce941ce32ce529b91df671ed14015bfba0c2596979db1117e7378274d1b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/rdma-core-62.0-3.el10.riscv64.rpm;name=riscv64_rdma-core;unpack=0"
SRC_URI[riscv64_rdma-core.sha256sum] = "814dd8a2329d7c2c130fdaa6f07ac5c96a9e4741d4d118ecc2802801a5640fbc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rdma-core-devel-62.0-3.el10.riscv64.rpm;name=riscv64_rdma-core-devel;unpack=0"
SRC_URI[riscv64_rdma-core-devel.sha256sum] = "1d25479a37649528f73ed1a8caed2dda7114ba24ab92015ebe538f3f8fcf9573"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/srp_daemon-62.0-3.el10.riscv64.rpm;name=riscv64_srp_daemon;unpack=0"
SRC_URI[riscv64_srp_daemon.sha256sum] = "cef8a71a705dc99eb1fde7d2d4d2b255e7b313b67154007fde3d26c0087f321d"

RDEPENDS:ibacm = " \
 bash \
 glibc \
 libibumad \
 libibverbs \
 libnl3 \
 systemd \
 systemd-libs \
 "
RDEPENDS:infiniband-diags = " \
 bash \
 glibc \
 libibumad \
 perl-Getopt-Std \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:iwpmd = " \
 bash \
 glibc \
 libnl3 \
 systemd \
 systemd-libs \
 "
RDEPENDS:libibumad = " \
 glibc \
 "
RDEPENDS:libibverbs = " \
 glibc \
 libnl3 \
 "
RDEPENDS:libibverbs-utils = " \
 glibc \
 libibverbs \
 "
RDEPENDS:librdmacm = " \
 glibc \
 libibverbs \
 libnl3 \
 "
RDEPENDS:librdmacm-utils = " \
 glibc \
 libibverbs \
 librdmacm \
 "
RDEPENDS:python3-pyverbs = " \
 glibc \
 libibverbs \
 librdmacm \
 python3 \
 python3-libs \
 "
RDEPENDS:rdma-core = " \
 bash \
 glibc \
 libnl3 \
 pciutils \
 python3 \
 systemd-libs \
 "
RDEPENDS:rdma-core-devel = " \
 infiniband-diags \
 libibumad \
 libibverbs \
 librdmacm \
 pkgconf-pkg-config \
 rdma-core-devel \
 "
RDEPENDS:srp_daemon = " \
 bash \
 glibc \
 libibumad \
 libibverbs \
 systemd \
 "
