# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipvsadm"
PV = "1.31"
PR = "15.el10"
PACKAGES = " \
 ipvsadm \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ipvsadm-1.31-15.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7e062034871b4237cda779dc54bef77ef78a629dda5cf6a44241affff6e63869"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipvsadm-1.31-15.el10.x86_64_v2.rpm;name=x86_64_v2_ipvsadm;unpack=0"
SRC_URI[x86_64_v2_ipvsadm.sha256sum] = "98c41326fd0f7e81f50909e5eea2d67ae86e76619b0873e35897ccf39a79c2d8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipvsadm-1.31-15.el10.aarch64.rpm;name=aarch64_ipvsadm;unpack=0"
SRC_URI[aarch64_ipvsadm.sha256sum] = "5fc84a95805fe1df2dc3dd51ba33778fd4865c618b80b16438a5f81fd8f63e03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/ipvsadm-1.31-15.el10.riscv64.rpm;name=riscv64_ipvsadm;unpack=0"
SRC_URI[riscv64_ipvsadm.sha256sum] = "c1ef8556e128113b272a159d425c8c29dbebafca893a11e183a8727a8664682a"

RDEPENDS:ipvsadm = " \
 bash \
 glibc \
 libnl3 \
 popt \
 systemd \
 "
