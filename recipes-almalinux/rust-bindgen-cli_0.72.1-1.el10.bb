# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bindgen-cli"
PV = "0.72.1"
PR = "1.el10"
PACKAGES = " \
 bindgen-cli \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/rust-bindgen-cli-0.72.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a90fcd85479f3aed6425e83f12f305bbc4029babe3fb7616ce8a7384b1c442a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bindgen-cli-0.72.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_bindgen-cli;unpack=0"
SRC_URI[x86_64_v2_bindgen-cli.sha256sum] = "b3d4297f3f5f96ee6fd35d73d916c1a35717c29ba78c1ed49248b42799a5ff6c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bindgen-cli-0.72.1-1.el10.aarch64.rpm;name=aarch64_bindgen-cli;unpack=0"
SRC_URI[aarch64_bindgen-cli.sha256sum] = "5544daa4e2bf17a70a007959c406c32e9798eded20b149fcfcdfed9c7b2f725b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/bindgen-cli-0.72.1-1.el10.riscv64.rpm;name=riscv64_bindgen-cli;unpack=0"
SRC_URI[riscv64_bindgen-cli.sha256sum] = "1d3f51570015ee29563a9417fb673580b0b01ca8ba8ff4060d8afc300ba2e5b0"

RDEPENDS:bindgen-cli = " \
 clang-libs \
 glibc \
 libgcc \
 "
