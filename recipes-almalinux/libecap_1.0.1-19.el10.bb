# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libecap"
PV = "1.0.1"
PR = "19.el10"
PACKAGES = " \
 libecap \
 libecap-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libecap-1.0.1-19.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c48825cb8b931dcec8d6a832253ec96b29124b8a254faaf5da9df5a009b34664"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libecap-1.0.1-19.el10.x86_64_v2.rpm;name=x86_64_v2_libecap;unpack=0"
SRC_URI[x86_64_v2_libecap.sha256sum] = "53ef1ee98f4e6efc28250aa33c70fe0d5014f4d6623500c63612ca0ea9f60d21"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libecap-devel-1.0.1-19.el10.x86_64_v2.rpm;name=x86_64_v2_libecap-devel;unpack=0"
SRC_URI[x86_64_v2_libecap-devel.sha256sum] = "0bde2cb9e446e01219ebea41933752a6d894032792b6e9b1014feb02bf6975c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libecap-1.0.1-19.el10.aarch64.rpm;name=aarch64_libecap;unpack=0"
SRC_URI[aarch64_libecap.sha256sum] = "c9070745b894557b2d3e69e9264cf6dd953d1e874c0e1a6d40be64bb56f9119c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libecap-devel-1.0.1-19.el10.aarch64.rpm;name=aarch64_libecap-devel;unpack=0"
SRC_URI[aarch64_libecap-devel.sha256sum] = "88db6aaf2e390c0cb3a0dca4d1d563af979577b0e2b0b859abbe5509a4bf90cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libecap-1.0.1-19.el10.riscv64.rpm;name=riscv64_libecap;unpack=0"
SRC_URI[riscv64_libecap.sha256sum] = "3952b3713ba0844f81b024e9285bc7d6e7cf7397d7fec30aff9c82420df8f07d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libecap-devel-1.0.1-19.el10.riscv64.rpm;name=riscv64_libecap-devel;unpack=0"
SRC_URI[riscv64_libecap-devel.sha256sum] = "057182cb93ae0981219940f1c5639b416a61b433d5bea0b24707340b7bd3cce9"

RDEPENDS:libecap = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libecap-devel = " \
 libecap \
 pkgconf-pkg-config \
 "
