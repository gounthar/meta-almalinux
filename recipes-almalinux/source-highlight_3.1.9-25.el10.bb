# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "source-highlight"
PV = "3.1.9"
PR = "25.el10"
PACKAGES = " \
 source-highlight \
 source-highlight-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/source-highlight-3.1.9-25.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dc42a9045c0754923ae84369ffcc7a22fc1d49a588cfdce3cd405d3bca1534d7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/source-highlight-3.1.9-25.el10.x86_64_v2.rpm;name=x86_64_v2_source-highlight;unpack=0"
SRC_URI[x86_64_v2_source-highlight.sha256sum] = "97bc57330b336358c6ec8185dd420750a33aec797fd23d9df96ddf4d2b56b03a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/source-highlight-devel-3.1.9-25.el10.x86_64_v2.rpm;name=x86_64_v2_source-highlight-devel;unpack=0"
SRC_URI[x86_64_v2_source-highlight-devel.sha256sum] = "97a3a50fde91cc86f19d33e4a22d756a513da4fd8f127a8c52121d7eb1d47a93"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/source-highlight-3.1.9-25.el10.aarch64.rpm;name=aarch64_source-highlight;unpack=0"
SRC_URI[aarch64_source-highlight.sha256sum] = "dd7219af99f2a7e7a885e15c4baa259552c68963a040f6564d60c24607fe4406"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/source-highlight-devel-3.1.9-25.el10.aarch64.rpm;name=aarch64_source-highlight-devel;unpack=0"
SRC_URI[aarch64_source-highlight-devel.sha256sum] = "9d4f8dd11c150a4ac5fdb07d85cbd8357a3f2fd0897010741bd9348ba2ee5ddb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/source-highlight-3.1.9-25.el10.riscv64.rpm;name=riscv64_source-highlight;unpack=0"
SRC_URI[riscv64_source-highlight.sha256sum] = "ac93bfec588c25bcef29e97340167a8bbc251ff831cdac64cdc14e5e34995ad8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/source-highlight-devel-3.1.9-25.el10.riscv64.rpm;name=riscv64_source-highlight-devel;unpack=0"
SRC_URI[riscv64_source-highlight-devel.sha256sum] = "e7c2911ad481b267b920af586f713ae7a1e7716c77d0d2dbc25dccec62d2b070"

RDEPENDS:source-highlight = " \
 bash \
 boost-regex \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:source-highlight-devel = " \
 boost-devel \
 pkgconf-pkg-config \
 source-highlight \
 "
