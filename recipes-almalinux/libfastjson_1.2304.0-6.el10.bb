# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libfastjson"
PV = "1.2304.0"
PR = "6.el10"
PACKAGES = " \
 libfastjson \
 libfastjson-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libfastjson-1.2304.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3f18663a2e284b3136306cc3f3374f49f35eaa1497e1231949973b4e20e24f8e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libfastjson-1.2304.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_libfastjson;unpack=0"
SRC_URI[x86_64_v2_libfastjson.sha256sum] = "3e8025e83ebf029ec73c04f00a88a88d80724604a37e2cce93746e988a85c17a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libfastjson-devel-1.2304.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_libfastjson-devel;unpack=0"
SRC_URI[x86_64_v2_libfastjson-devel.sha256sum] = "dbf6830662d9b1b110638bb98b949e503d4b103d38329ba519171079f97069c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libfastjson-1.2304.0-6.el10.aarch64.rpm;name=aarch64_libfastjson;unpack=0"
SRC_URI[aarch64_libfastjson.sha256sum] = "bb4fac4bd4f42421607e469a556d2f2507dfa588481e99438fb1587f758ef9ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libfastjson-devel-1.2304.0-6.el10.aarch64.rpm;name=aarch64_libfastjson-devel;unpack=0"
SRC_URI[aarch64_libfastjson-devel.sha256sum] = "c195eee6bc4f7800a8719de5e93dc6de956374a4f3eb847d2bf12133a4fe3c80"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libfastjson-1.2304.0-6.el10.riscv64.rpm;name=riscv64_libfastjson;unpack=0"
SRC_URI[riscv64_libfastjson.sha256sum] = "f3d984cf5020e466823131ac63e44d1d9105c4fa1f19d7cdf41891f566bcdc6c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/libfastjson-devel-1.2304.0-6.el10.riscv64.rpm;name=riscv64_libfastjson-devel;unpack=0"
SRC_URI[riscv64_libfastjson-devel.sha256sum] = "81c0bc6251d34db306b5dcbb4b2fa2ac83a4a1f33cdb7e3c32ff5af5bd304193"

RDEPENDS:libfastjson = " \
 glibc \
 "
RDEPENDS:libfastjson-devel = " \
 libfastjson \
 pkgconf-pkg-config \
 "
