# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libksba"
PV = "1.6.7"
PR = "2.el10"
PACKAGES = " \
 libksba \
 libksba-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libksba-1.6.7-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a38d598597fb50c51ffc8beb35a6f824ad8020000b0c7e2de1f8377bc3404a70"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libksba-1.6.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_libksba;unpack=0"
SRC_URI[x86_64_v2_libksba.sha256sum] = "fc734db4e771e84015687cf90810aebf2e9c6ba7d157f12cf13b01c5c282550e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libksba-devel-1.6.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_libksba-devel;unpack=0"
SRC_URI[x86_64_v2_libksba-devel.sha256sum] = "d9cb7add9d645839ddfc0a996dcf489b3ee19453aa1c95079798b1be9630a532"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libksba-1.6.7-2.el10.aarch64.rpm;name=aarch64_libksba;unpack=0"
SRC_URI[aarch64_libksba.sha256sum] = "f7e50f3491c7ba01c098585ee98351c375abc440234dfbd1317703e734cde0fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libksba-devel-1.6.7-2.el10.aarch64.rpm;name=aarch64_libksba-devel;unpack=0"
SRC_URI[aarch64_libksba-devel.sha256sum] = "150539c2ef14af0b87ea2bc8d0b7a17ac068a4dcd7482820547b2c9ac376edc9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libksba-1.6.7-2.el10.riscv64.rpm;name=riscv64_libksba;unpack=0"
SRC_URI[riscv64_libksba.sha256sum] = "81b9e77d636cb971f5f44c276df29d68ce3cb396477a037317011079d166139f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/libksba-devel-1.6.7-2.el10.riscv64.rpm;name=riscv64_libksba-devel;unpack=0"
SRC_URI[riscv64_libksba-devel.sha256sum] = "a4c37144ad77bdf4b777b90bbad23604fa417c62ef5b6cde4f86ff1c8184e8ef"

RDEPENDS:libksba = " \
 glibc \
 libgpg-error \
 "
RDEPENDS:libksba-devel = " \
 bash \
 libgpg-error-devel \
 libksba \
 pkgconf-pkg-config \
 "
