# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-color-manager"
PV = "3.36.0"
PR = "14.el10"
PACKAGES = " \
 gnome-color-manager \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-color-manager-3.36.0-14.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b902e518751ff8ceca58de9a9e1eda7c41153d22a5397f016763522111786be3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-color-manager-3.36.0-14.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-color-manager;unpack=0"
SRC_URI[x86_64_v2_gnome-color-manager.sha256sum] = "a20004ae6fbcdd5e23903df83f349d480c1d17d506054c011af751102d1bd27b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-color-manager-3.36.0-14.el10.aarch64.rpm;name=aarch64_gnome-color-manager;unpack=0"
SRC_URI[aarch64_gnome-color-manager.sha256sum] = "6c25dbfb17f194791a64a2d1333fcbf8d12b5a2be8a2e4a5badb8e004e3937cb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gnome-color-manager-3.36.0-14.el10.riscv64.rpm;name=riscv64_gnome-color-manager;unpack=0"
SRC_URI[riscv64_gnome-color-manager.sha256sum] = "8cc52062ca50144d1d23ac9d3e5de387d80ae65c9bfd35a11f3749f4ccdc420b"

RDEPENDS:gnome-color-manager = " \
 cairo \
 colord-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 lcms2 \
 libgcc \
 pango \
 shared-mime-info \
 "
