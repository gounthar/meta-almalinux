# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php"
PV = "8.3.33"
PR = "1.el10"
PACKAGES = " \
 php \
 php-bcmath \
 php-cli \
 php-common \
 php-dba \
 php-dbg \
 php-devel \
 php-embedded \
 php-enchant \
 php-ffi \
 php-fpm \
 php-gd \
 php-gmp \
 php-intl \
 php-ldap \
 php-mbstring \
 php-mysqlnd \
 php-odbc \
 php-opcache \
 php-pdo \
 php-pgsql \
 php-process \
 php-snmp \
 php-soap \
 php-xml \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/php-8.3.33-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dca158255f3636ec6096b6c7bcd002a8a8e98ae4f54e46040eeba89de80e30c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php;unpack=0"
SRC_URI[x86_64_v2_php.sha256sum] = "ca212b4d71d7a11e73e81f020e49d15b6261dd65e41845b8f66a29f0e920a784"
RPROVIDES:php:append:x86_64_v2 = " virtual/php"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-bcmath-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-bcmath;unpack=0"
SRC_URI[x86_64_v2_php-bcmath.sha256sum] = "2bc82a657756e206d111efeacbe98e20c702bfef02f3ae5d0dfdd5a735caaf4f"
RPROVIDES:php-bcmath:append:x86_64_v2 = " virtual/php-bcmath"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-cli-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-cli;unpack=0"
SRC_URI[x86_64_v2_php-cli.sha256sum] = "828c8f99957cfa3cf86af34615ee1814dc8c2945c0da25673878a08739ffc5af"
RPROVIDES:php-cli:append:x86_64_v2 = " virtual//usr/bin/php virtual/php-cli virtual/php-pcntl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-common-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-common;unpack=0"
SRC_URI[x86_64_v2_php-common.sha256sum] = "653d8d735a1b3d09f7facec61e13909f4bd98a29bfdf3540e38753046ca0af8d"
RPROVIDES:php-common:append:x86_64_v2 = " virtual/php-bz2 virtual/php-ctype virtual/php-curl virtual/php-date virtual/php-exif virtual/php-fileinfo virtual/php-filter virtual/php-ftp virtual/php-gettext virtual/php-hash virtual/php-iconv virtual/php-iconv_x86-64_ virtual/php-json virtual/php-json_x86-64_ virtual/php-libxml virtual/php-mhash virtual/php-openssl virtual/php-pcre virtual/php-phar virtual/php-reflection virtual/php-session virtual/php-sockets virtual/php-sockets_x86-64_ virtual/php-spl virtual/php-spl_x86-64_ virtual/php-tokenizer virtual/php-tokenizer_x86-64_ virtual/php-zlib virtual/php_language__ge_5.3.0 virtual/php_language__ge_5.3.1 virtual/php_language__ge_5.3.3 virtual/php_language__ge_7.1 virtual/php_language__ge_7.2 virtual/php_language__ge_7.2.5 virtual/php_language__ge_7.3 virtual/php_language__ge_7.4 virtual/php_language__ge_8.1 virtual/php_language__gt_5.3 virtual/php_language__gt_5.4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-dba-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-dba;unpack=0"
SRC_URI[x86_64_v2_php-dba.sha256sum] = "a91fe0057e48b56be078298e542e30423fec705c8ed18d0f5ae04609c3cd0eac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-dbg-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-dbg;unpack=0"
SRC_URI[x86_64_v2_php-dbg.sha256sum] = "69053313799607b6f29437e66698109e8e976ba82a0e711c3f141f8244a9c61c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-devel-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-devel;unpack=0"
SRC_URI[x86_64_v2_php-devel.sha256sum] = "c739bba419a6ce33e1b2c6f924f8b05c006ba3af6ae52a6d7736be1e590ac827"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-embedded-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-embedded;unpack=0"
SRC_URI[x86_64_v2_php-embedded.sha256sum] = "95c9d824c98ad41c60f462674a07bde73eec14e83662519adf47a0aba7e7e983"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-enchant-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-enchant;unpack=0"
SRC_URI[x86_64_v2_php-enchant.sha256sum] = "36b73478c6a9019e110bb4805a05a4300e5989029c19442a25757f4b13aff98d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-ffi-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-ffi;unpack=0"
SRC_URI[x86_64_v2_php-ffi.sha256sum] = "4aae3548bef2bc5b0a87f2425471000a24a5e337d8a36eeb9b905652eb0de992"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-fpm-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-fpm;unpack=0"
SRC_URI[x86_64_v2_php-fpm.sha256sum] = "9c1e8fa715374f2964a0f40fd11d322e6de5bb122ba6be951f367320ffcc6921"
RPROVIDES:php-fpm:append:x86_64_v2 = " virtual/php-fpm virtual/php-fpm_ge_8.0 virtual/php_httpd_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-gd-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-gd;unpack=0"
SRC_URI[x86_64_v2_php-gd.sha256sum] = "c2adf1f3d0d6ba22b073d75a692cd2e1426a39adb8bc492073d05d990e2c5801"
RPROVIDES:php-gd:append:x86_64_v2 = " virtual/php-gd virtual/php-gd_x86-64_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-gmp-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-gmp;unpack=0"
SRC_URI[x86_64_v2_php-gmp.sha256sum] = "d82398e5479a6e21cd24454cf268d380c7fa569ad8274f98cd9cfbb98b5f197a"
RPROVIDES:php-gmp:append:x86_64_v2 = " virtual/php-gmp"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-intl-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-intl;unpack=0"
SRC_URI[x86_64_v2_php-intl.sha256sum] = "40879c317d718de69c99e58202b1d7f13a8264ddb8e3d110499a86bdbe740533"
RPROVIDES:php-intl:append:x86_64_v2 = " virtual/php-intl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-ldap-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-ldap;unpack=0"
SRC_URI[x86_64_v2_php-ldap.sha256sum] = "336a38070977264d00556bbdc375b8254d4f63ddaaa0bcc7bd08abc35b1f057d"
RPROVIDES:php-ldap:append:x86_64_v2 = " virtual/php-ldap"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-mbstring-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-mbstring;unpack=0"
SRC_URI[x86_64_v2_php-mbstring.sha256sum] = "e1b6e6dd8ca5c1e3d6d9b89fad327491ddc1fbd38a8ac80685c52516662406cc"
RPROVIDES:php-mbstring:append:x86_64_v2 = " virtual/php-mbstring"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-mysqlnd-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-mysqlnd;unpack=0"
SRC_URI[x86_64_v2_php-mysqlnd.sha256sum] = "e96b5a5e8261a9492bfd58ba2589eb725238da8e016698952f01da9f5036db98"
RPROVIDES:php-mysqlnd:append:x86_64_v2 = " virtual/php-mysqli virtual/php-mysqlnd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-odbc-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-odbc;unpack=0"
SRC_URI[x86_64_v2_php-odbc.sha256sum] = "82437090686ec24852a57148b09dd4350396be2410ba5614dfa0500c2a83ea50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-opcache-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-opcache;unpack=0"
SRC_URI[x86_64_v2_php-opcache.sha256sum] = "bafe3b257b424b98ca23217274a5c243922b6381c172a623c32ae490373688cf"
RPROVIDES:php-opcache:append:x86_64_v2 = " virtual/php-opcache"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-pdo-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-pdo;unpack=0"
SRC_URI[x86_64_v2_php-pdo.sha256sum] = "929510ec1bb1e5d843d54afca8a18f9955e6e045014d8892144798c8a22044d5"
RPROVIDES:php-pdo:append:x86_64_v2 = " virtual/php-pdo virtual/php-sqlite3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-pgsql-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-pgsql;unpack=0"
SRC_URI[x86_64_v2_php-pgsql.sha256sum] = "9e70aec09e6865387d29ccda12c8edc0a9ea79b858de4aaba93e5fe3f82b4001"
RPROVIDES:php-pgsql:append:x86_64_v2 = " virtual/php-pgsql"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-process-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-process;unpack=0"
SRC_URI[x86_64_v2_php-process.sha256sum] = "df065bb8ba35d1c1987c99e9872f1d04836d7a566a87cda8c78479bed9b528df"
RPROVIDES:php-process:append:x86_64_v2 = " virtual/php-posix virtual/php-process"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-snmp-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-snmp;unpack=0"
SRC_URI[x86_64_v2_php-snmp.sha256sum] = "a1c2c7e8c7aed792a3300ceee8c273886eecedd462e54184c7103a7591bc8ad3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-soap-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-soap;unpack=0"
SRC_URI[x86_64_v2_php-soap.sha256sum] = "a005be53be9641694a3e97cfbcad4cf262823433059aec987b5d715b356d6784"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-xml-8.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-xml;unpack=0"
SRC_URI[x86_64_v2_php-xml.sha256sum] = "23fa14356ea5d53ed8dc3cd212f5069cf2899ba14e83e1ddc36d4881938353e3"
RPROVIDES:php-xml:append:x86_64_v2 = " virtual/php-dom virtual/php-simplexml virtual/php-xml virtual/php-xmlreader virtual/php-xmlwriter virtual/php-xsl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-8.3.33-1.el10.aarch64.rpm;name=aarch64_php;unpack=0"
SRC_URI[aarch64_php.sha256sum] = "3083cbe190d7107e2fc5861ec620e3923bf9e687993848812d036d1c1728086f"
RPROVIDES:php:append:aarch64 = " virtual/php"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-bcmath-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-bcmath;unpack=0"
SRC_URI[aarch64_php-bcmath.sha256sum] = "d43ef1bb5bf47f08240ad8d27f576784e7f5925f298f1f9ffbbb0625e9b5d890"
RPROVIDES:php-bcmath:append:aarch64 = " virtual/php-bcmath"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-cli-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-cli;unpack=0"
SRC_URI[aarch64_php-cli.sha256sum] = "ad2dab8247cfc13f4248d1d743e6149a2a599ce926b14f6dd118b8b3b152d049"
RPROVIDES:php-cli:append:aarch64 = " virtual//usr/bin/php virtual/php-cli virtual/php-pcntl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-common-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-common;unpack=0"
SRC_URI[aarch64_php-common.sha256sum] = "fb454c47693c2ee064a2f81c0964d412aeaae5a863e7367cc60efdd58cbf82b6"
RPROVIDES:php-common:append:aarch64 = " virtual/php-bz2 virtual/php-ctype virtual/php-curl virtual/php-date virtual/php-exif virtual/php-fileinfo virtual/php-filter virtual/php-ftp virtual/php-gettext virtual/php-hash virtual/php-iconv virtual/php-iconv_aarch-64_ virtual/php-json virtual/php-json_aarch-64_ virtual/php-libxml virtual/php-mhash virtual/php-openssl virtual/php-pcre virtual/php-phar virtual/php-reflection virtual/php-session virtual/php-sockets virtual/php-sockets_aarch-64_ virtual/php-spl virtual/php-spl_aarch-64_ virtual/php-tokenizer virtual/php-tokenizer_aarch-64_ virtual/php-zlib virtual/php_language__ge_5.3.0 virtual/php_language__ge_5.3.1 virtual/php_language__ge_5.3.3 virtual/php_language__ge_7.1 virtual/php_language__ge_7.2 virtual/php_language__ge_7.2.5 virtual/php_language__ge_7.3 virtual/php_language__ge_7.4 virtual/php_language__ge_8.1 virtual/php_language__gt_5.3 virtual/php_language__gt_5.4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-dba-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-dba;unpack=0"
SRC_URI[aarch64_php-dba.sha256sum] = "99d7b3c8fda15eba85fc7a9e8df781036c6cd60bce208d6aaefc9c9a0504d164"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-dbg-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-dbg;unpack=0"
SRC_URI[aarch64_php-dbg.sha256sum] = "6852b233745c5a28c35f93d50a336ee8947e712b4abbc39ad59314b07ca05ce2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-devel-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-devel;unpack=0"
SRC_URI[aarch64_php-devel.sha256sum] = "842caf4de2262b6a8f087a271d0f3c71cca287c53eb81d755373c15da5e9145f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-embedded-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-embedded;unpack=0"
SRC_URI[aarch64_php-embedded.sha256sum] = "deb2247e7eb045790e11ac8143335b86a61e30efc263a50c3128411d54b2e323"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-enchant-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-enchant;unpack=0"
SRC_URI[aarch64_php-enchant.sha256sum] = "669ab5dacff1c36a140f000e872d130838c6ae6fc9647f8d888bbc9fe264fd57"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-ffi-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-ffi;unpack=0"
SRC_URI[aarch64_php-ffi.sha256sum] = "edadcf5fedb39ea8385b29bb92179ca6dc48c8dc596711d11fff75f9aa0ba446"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-fpm-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-fpm;unpack=0"
SRC_URI[aarch64_php-fpm.sha256sum] = "0deb331dec225b35035c9d727cd0a9e03d07698cdfba85953307827dc181ab11"
RPROVIDES:php-fpm:append:aarch64 = " virtual/php-fpm virtual/php-fpm_ge_8.0 virtual/php_httpd_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-gd-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-gd;unpack=0"
SRC_URI[aarch64_php-gd.sha256sum] = "76b2bea7ca00ab48b6c964aee20251c75f56da71f3641ed7b1696c0d9dee98e9"
RPROVIDES:php-gd:append:aarch64 = " virtual/php-gd virtual/php-gd_aarch-64_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-gmp-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-gmp;unpack=0"
SRC_URI[aarch64_php-gmp.sha256sum] = "3a00a9d6190be33be4a3e039dfec6d1bff81bb165c6c620380ec17d68cfa1d1c"
RPROVIDES:php-gmp:append:aarch64 = " virtual/php-gmp"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-intl-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-intl;unpack=0"
SRC_URI[aarch64_php-intl.sha256sum] = "7310d9d8bbfe2e910dd2662b0a3528a18a517149e207e5a76a7368a7049da9e9"
RPROVIDES:php-intl:append:aarch64 = " virtual/php-intl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-ldap-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-ldap;unpack=0"
SRC_URI[aarch64_php-ldap.sha256sum] = "e2acc9bddbe675f89148be22e934c4bf3f4d3cc126fd027a840bb1d39dc36a45"
RPROVIDES:php-ldap:append:aarch64 = " virtual/php-ldap"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-mbstring-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-mbstring;unpack=0"
SRC_URI[aarch64_php-mbstring.sha256sum] = "3ceb5f50aa8356f1ebf1f735030ded23296b5b7f7c0eae3c7ad7abaf09526d7e"
RPROVIDES:php-mbstring:append:aarch64 = " virtual/php-mbstring"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-mysqlnd-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-mysqlnd;unpack=0"
SRC_URI[aarch64_php-mysqlnd.sha256sum] = "d9f54ed33f6a74b08545f7805ddd0e48d4efcbf38880f360f8362be53211830d"
RPROVIDES:php-mysqlnd:append:aarch64 = " virtual/php-mysqli virtual/php-mysqlnd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-odbc-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-odbc;unpack=0"
SRC_URI[aarch64_php-odbc.sha256sum] = "a48a035e07a105bef921310ad631c206f6ba546514fb012d59e22e88a8f222b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-opcache-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-opcache;unpack=0"
SRC_URI[aarch64_php-opcache.sha256sum] = "f242a40dedb025e074c37a7d4b6535ea33c5b9188ef2a5bc6e2ca6c2a210a41a"
RPROVIDES:php-opcache:append:aarch64 = " virtual/php-opcache"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-pdo-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-pdo;unpack=0"
SRC_URI[aarch64_php-pdo.sha256sum] = "c94ad0ca332945e7238d7c07c60dc3f7111c7a95910f2ff0867001f572e84c18"
RPROVIDES:php-pdo:append:aarch64 = " virtual/php-pdo virtual/php-sqlite3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-pgsql-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-pgsql;unpack=0"
SRC_URI[aarch64_php-pgsql.sha256sum] = "59fa9be3030166aa4ab5fc1614f703c148a989b3f2ace1c365adfa4588449997"
RPROVIDES:php-pgsql:append:aarch64 = " virtual/php-pgsql"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-process-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-process;unpack=0"
SRC_URI[aarch64_php-process.sha256sum] = "28326613efdf3a877b82def330f88a01aab506c4ab18b0ad9e177d213c62f32a"
RPROVIDES:php-process:append:aarch64 = " virtual/php-posix virtual/php-process"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-snmp-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-snmp;unpack=0"
SRC_URI[aarch64_php-snmp.sha256sum] = "6f0cf5a67e299fe8cd5325df6d6545302deafd24f7ac7c67994c18e704e39373"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-soap-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-soap;unpack=0"
SRC_URI[aarch64_php-soap.sha256sum] = "c0492a4447bea4449f94152b3562ff9284c866be5b00392cad491dfda666b8a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-xml-8.3.33-1.el10.aarch64.rpm;name=aarch64_php-xml;unpack=0"
SRC_URI[aarch64_php-xml.sha256sum] = "f97858ece26c8cf1d2bbb3982e4fbcb0a2cc043d62b7bb5230a23898edd1a7b2"
RPROVIDES:php-xml:append:aarch64 = " virtual/php-dom virtual/php-simplexml virtual/php-xml virtual/php-xmlreader virtual/php-xmlwriter virtual/php-xsl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-8.3.33-1.el10.riscv64.rpm;name=riscv64_php;unpack=0"
SRC_URI[riscv64_php.sha256sum] = "48b9e036945859b14d9761c414d5066fac92c4ce7e0c9ece343321b88fe09cc4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-bcmath-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-bcmath;unpack=0"
SRC_URI[riscv64_php-bcmath.sha256sum] = "31ae6670da759c4d7f41f6ba6824e2bae55230ea5e5b017e9c0bc99489d327df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-cli-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-cli;unpack=0"
SRC_URI[riscv64_php-cli.sha256sum] = "9c2695df45200860ad157155ed0f78d39ffb7754eace66621a96c3b4b7861f82"
RPROVIDES:php-cli:append:riscv64 = " virtual/php-cli"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-common-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-common;unpack=0"
SRC_URI[riscv64_php-common.sha256sum] = "66f5e808f93152ab700e08a2845285e96401f9a463b723aa00bc2bb2e44dbedb"
RPROVIDES:php-common:append:riscv64 = " virtual/php-bz2 virtual/php-ftp virtual/php-json_riscv-64_ virtual/php-pcre virtual/php-tokenizer virtual/php-zlib virtual/php_language__gt_5.4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-dba-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-dba;unpack=0"
SRC_URI[riscv64_php-dba.sha256sum] = "dedbd938dbef92cc59416b7d3adc1f7e1d46fd5ae30384a6d6b655e71ddef922"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-dbg-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-dbg;unpack=0"
SRC_URI[riscv64_php-dbg.sha256sum] = "b5d59faf2c682552011c9a4d91ffb47da0bd70e4bc23e2c43417c3dbf7b8c5e8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-devel-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-devel;unpack=0"
SRC_URI[riscv64_php-devel.sha256sum] = "1a5fd528b4b822ade22f2a8f813d8032e386034a436d7a2e2a305dd4b4bc6374"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-embedded-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-embedded;unpack=0"
SRC_URI[riscv64_php-embedded.sha256sum] = "4b65cb6254f380fa05bab58ab87b9611cc338b234560a010705198f751fd9248"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-enchant-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-enchant;unpack=0"
SRC_URI[riscv64_php-enchant.sha256sum] = "cbfc0fc4a3eca04bf7bb18288a4f25aadfa157c1331201a2fe9dcf59482c9f33"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-ffi-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-ffi;unpack=0"
SRC_URI[riscv64_php-ffi.sha256sum] = "21cb9d854cb658e7f531263d8093c0abee721dde9923b4abde35824ffd34d475"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-fpm-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-fpm;unpack=0"
SRC_URI[riscv64_php-fpm.sha256sum] = "43da495743e30c8560927ae2d4f02fc602afe8b2e65aad566a8994bb5e393b97"
RPROVIDES:php-fpm:append:riscv64 = " virtual/php_httpd_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-gd-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-gd;unpack=0"
SRC_URI[riscv64_php-gd.sha256sum] = "343c48e3341287179f5c3d60ef63728c11dede3eb69d54c13fab6ec439f23b89"
RPROVIDES:php-gd:append:riscv64 = " virtual/php-gd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-gmp-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-gmp;unpack=0"
SRC_URI[riscv64_php-gmp.sha256sum] = "f1965a61dd3ed54969d976f9386fa8464f5e2699e7aa1a71cdf992e9ead8cb6d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-intl-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-intl;unpack=0"
SRC_URI[riscv64_php-intl.sha256sum] = "5b62d243635b686dacb5720f45fbc7f75fb06514cd12f57c2c6180ef5b9d049b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-ldap-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-ldap;unpack=0"
SRC_URI[riscv64_php-ldap.sha256sum] = "1e240bfd7ec7bf76a040e2706557bda5528966beacefb179c8d0962553a59b3f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-mbstring-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-mbstring;unpack=0"
SRC_URI[riscv64_php-mbstring.sha256sum] = "f552a5b308f0c1ef5e741561766c79c22bab6e2b64ee6db6c1a9579bc42aa568"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-mysqlnd-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-mysqlnd;unpack=0"
SRC_URI[riscv64_php-mysqlnd.sha256sum] = "9937a93a888018b178f246292de1b6e5fe6d3a3a10e3c67d536c23db1eefc028"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-odbc-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-odbc;unpack=0"
SRC_URI[riscv64_php-odbc.sha256sum] = "6bbe7093144430dd87719a67a65d37ea03d0b3f0595f59c95f4990532a791757"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-opcache-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-opcache;unpack=0"
SRC_URI[riscv64_php-opcache.sha256sum] = "dcbaa474656455fdd49b92cb7b7e99b75d6cf0579de1c9d75ddfbc6f8637b0b6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-pdo-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-pdo;unpack=0"
SRC_URI[riscv64_php-pdo.sha256sum] = "e9c5bf8baa5cac7a041fe6b1d1863f194319f4d70d6d7e36c3b22faf9d55707d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-pgsql-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-pgsql;unpack=0"
SRC_URI[riscv64_php-pgsql.sha256sum] = "0461ce6281c182adf211b0db69cbe8649c3032a7f8b313b35151e13efd4a29f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-process-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-process;unpack=0"
SRC_URI[riscv64_php-process.sha256sum] = "5281d4d5c525995c43630021574575fc7a0c20b5dd9b261e5b64cbfae6a625a3"
RPROVIDES:php-process:append:riscv64 = " virtual/php-posix"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-snmp-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-snmp;unpack=0"
SRC_URI[riscv64_php-snmp.sha256sum] = "4dbec7c5dabcdab1b98d230192e7803434232ea429904588079dd8798a5965e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-soap-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-soap;unpack=0"
SRC_URI[riscv64_php-soap.sha256sum] = "7fc19df630a3d535cd46326df9f86f6376287d5e98c9a4f2f5ce18f615793b87"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/php-xml-8.3.33-1.el10.riscv64.rpm;name=riscv64_php-xml;unpack=0"
SRC_URI[riscv64_php-xml.sha256sum] = "d7efd64f7edcdab261e3437360e8ef007d98fe8d7a5bee826e34dd4c3867a898"
RPROVIDES:php-xml:append:riscv64 = " virtual/php-xml"

RDEPENDS:php = " \
 php-common \
 "
RDEPENDS:php-bcmath = " \
 glibc \
 php-common \
 "
RDEPENDS:php-cli = " \
 bash \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-common = " \
 bzip2-libs \
 glibc \
 openssl-libs \
 tzdata \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:php-dba = " \
 glibc \
 lmdb-libs \
 php-common \
 tokyocabinet \
 "
RDEPENDS:php-dbg = " \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-devel = " \
 autoconf \
 automake \
 bash \
 gcc \
 gcc-c++ \
 krb5-devel \
 libtool \
 libxml2-devel \
 make \
 openssl-devel \
 pcre2-devel \
 php-cli \
 zlib-ng-compat-devel \
 "
RDEPENDS:php-embedded:x86_64_v2 = " \
 glibc \
 krb5-libs \
 libcom_err \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
"
RDEPENDS:php-embedded:aarch64 = " \
 glibc \
 krb5-libs \
 libcom_err \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
"
RDEPENDS:php-embedded:riscv64 = " \
 glibc \
 krb5-libs \
 libatomic \
 libcom_err \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
"
RDEPENDS:php-enchant = " \
 enchant2 \
 glibc \
 php-common \
 "
RDEPENDS:php-ffi = " \
 glibc \
 libffi \
 php-common \
 "
RDEPENDS:php-fpm = " \
 bash \
 glibc \
 httpd-filesystem \
 libacl \
 libselinux \
 libxcrypt \
 libxml2 \
 nginx-filesystem \
 openssl-libs \
 pcre2 \
 php-common \
 systemd \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:php-gd = " \
 gd \
 glibc \
 php-common \
 "
RDEPENDS:php-gmp = " \
 glibc \
 gmp \
 php-common \
 "
RDEPENDS:php-intl = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 php-common \
 "
RDEPENDS:php-ldap = " \
 cyrus-sasl-lib \
 glibc \
 openldap \
 php-common \
 "
RDEPENDS:php-mbstring = " \
 glibc \
 oniguruma \
 php-common \
 "
RDEPENDS:php-mysqlnd = " \
 glibc \
 php-pdo \
 "
RDEPENDS:php-odbc = " \
 glibc \
 php-pdo \
 unixODBC \
 "
RDEPENDS:php-opcache:x86_64_v2 = " \
 capstone \
 glibc \
 libgcc \
 php-common \
"
RDEPENDS:php-opcache:aarch64 = " \
 capstone \
 glibc \
 php-common \
"
RDEPENDS:php-opcache:riscv64 = " \
 glibc \
 php-common \
"
RDEPENDS:php-pdo = " \
 glibc \
 php-common \
 sqlite-libs \
 "
RDEPENDS:php-pgsql = " \
 glibc \
 libpq \
 php-pdo \
 "
RDEPENDS:php-process = " \
 glibc \
 php-common \
 "
RDEPENDS:php-snmp = " \
 glibc \
 net-snmp \
 net-snmp-libs \
 openssl-libs \
 php-common \
 "
RDEPENDS:php-soap = " \
 glibc \
 libxml2 \
 php-common \
 "
RDEPENDS:php-xml = " \
 glibc \
 libxml2 \
 libxslt \
 php-common \
 "
