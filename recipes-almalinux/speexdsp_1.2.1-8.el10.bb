# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "speexdsp"
PV = "1.2.1"
PR = "8.el10"
PACKAGES = " \
 speexdsp \
 speexdsp-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/speexdsp-1.2.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "37336065207169a18b68110f40f4aad7536cff198da5eb2b6e0e0e136ba95442"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/speexdsp-1.2.1-8.el10.x86_64_v2.rpm;name=x86_64_v2_speexdsp;unpack=0"
SRC_URI[x86_64_v2_speexdsp.sha256sum] = "9328ebbdc61a4af196a386e32b6eed1ddbb2715819cc91a2c8a6586d9a0a30d5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/speexdsp-devel-1.2.1-8.el10.x86_64_v2.rpm;name=x86_64_v2_speexdsp-devel;unpack=0"
SRC_URI[x86_64_v2_speexdsp-devel.sha256sum] = "519560e85f8e2e9f448588da684a6f279c288db7f465e35780541e8c67e0b7b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/speexdsp-1.2.1-8.el10.aarch64.rpm;name=aarch64_speexdsp;unpack=0"
SRC_URI[aarch64_speexdsp.sha256sum] = "57df623db900723cc7b56219ac359202959dd49ba78a12ef99f41ceb6b6bf533"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/speexdsp-devel-1.2.1-8.el10.aarch64.rpm;name=aarch64_speexdsp-devel;unpack=0"
SRC_URI[aarch64_speexdsp-devel.sha256sum] = "3ab52dc80cecfa625781c7d047c1eb0581f88b40e47ef83350e00ed3290a6c47"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/speexdsp-1.2.1-8.el10.riscv64.rpm;name=riscv64_speexdsp;unpack=0"
SRC_URI[riscv64_speexdsp.sha256sum] = "1d3c5f37ddb8ad4e6b2ca6a9f41bab284587689976514d08bfc99e4ff42d233e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/speexdsp-devel-1.2.1-8.el10.riscv64.rpm;name=riscv64_speexdsp-devel;unpack=0"
SRC_URI[riscv64_speexdsp-devel.sha256sum] = "641ecd99be7c732f305da5d8d881b86e382f9957f4aaf574a5384b92d503285d"

RDEPENDS:speexdsp = " \
 glibc \
 "
RDEPENDS:speexdsp-devel = " \
 pkgconf-pkg-config \
 speexdsp \
 "
