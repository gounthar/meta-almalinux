# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sssd"
PV = "2.13.1"
PR = "3.el10"
PACKAGES = " \
 libipa_hbac \
 libsss_autofs \
 libsss_certmap \
 libsss_idmap \
 libsss_nss_idmap \
 libsss_nss_idmap-devel \
 libsss_sudo \
 python3-libipa_hbac \
 python3-libsss_nss_idmap \
 python3-sss \
 python3-sss-murmur \
 python3-sssdconfig \
 sssd \
 sssd-ad \
 sssd-client \
 sssd-common \
 sssd-common-pac \
 sssd-dbus \
 sssd-idp \
 sssd-ipa \
 sssd-kcm \
 sssd-krb5 \
 sssd-krb5-common \
 sssd-ldap \
 sssd-nfs-idmap \
 sssd-passkey \
 sssd-proxy \
 sssd-tools \
 sssd-winbind-idmap \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sssd-2.13.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "22cf3bc3349f54578d1b413538befdf512fb144889a3c5b35df87f85904f0f78"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - python3-sss: libcap.so.2()(64bit)
# - sssd-ad: libcap.so.2()(64bit)
# - sssd-common: libcap.so.2()(64bit)
# - sssd-idp: libcap.so.2()(64bit)
# - sssd-ipa: libcap.so.2()(64bit)
# - sssd-krb5-common: libcap.so.2()(64bit)
# - sssd-krb5: libcap.so.2()(64bit)
# - sssd-ldap: libcap.so.2()(64bit)
# - sssd-proxy: libcap.so.2()(64bit)

## Requires (riscv64) that were seen as not satisfiable in original repo:
# - python3-sss: libcap.so.2()(64bit)
# - sssd-ad: libcap.so.2()(64bit)
# - sssd-common: libcap.so.2()(64bit)
# - sssd-idp: libcap.so.2()(64bit)
# - sssd-ipa: libcap.so.2()(64bit)
# - sssd-krb5-common: libcap.so.2()(64bit)
# - sssd-krb5: libcap.so.2()(64bit)
# - sssd-ldap: libcap.so.2()(64bit)
# - sssd-proxy: libcap.so.2()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libipa_hbac-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_libipa_hbac;unpack=0"
SRC_URI[x86_64_v2_libipa_hbac.sha256sum] = "55d120b540bce19d6937a97942b9263173a348a31cd1dea9ec0cdcd99cdf345e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_autofs-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_libsss_autofs;unpack=0"
SRC_URI[x86_64_v2_libsss_autofs.sha256sum] = "eee63b2c81ff45fdff5b0173a23b3cde147e5b4b4879832b9d1aff026c5873e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_certmap-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_libsss_certmap;unpack=0"
SRC_URI[x86_64_v2_libsss_certmap.sha256sum] = "96a0c54b6b296afa6b88ccf5270d9ecd6956e1eb068e5fdd04eab9553b9cbddf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_idmap-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_libsss_idmap;unpack=0"
SRC_URI[x86_64_v2_libsss_idmap.sha256sum] = "075b063e38d8ef56309db8c3d32d01455c8f807e9bb810d95a84fdeeb93db5c8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_nss_idmap-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_libsss_nss_idmap;unpack=0"
SRC_URI[x86_64_v2_libsss_nss_idmap.sha256sum] = "01ea2f009834e289f5018268ccd9065ee1303f5f1f9d9cf4c2c6496049752d03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsss_nss_idmap-devel-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_libsss_nss_idmap-devel;unpack=0"
SRC_URI[x86_64_v2_libsss_nss_idmap-devel.sha256sum] = "09538d4394f6452931cbd61d29f451dc9e585972708eeaf9272c1a9afc828144"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_sudo-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_libsss_sudo;unpack=0"
SRC_URI[x86_64_v2_libsss_sudo.sha256sum] = "a54adbc5362174264e196a1e8f595623797785885e1e450c5246ab605eef5647"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libipa_hbac-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libipa_hbac;unpack=0"
SRC_URI[x86_64_v2_python3-libipa_hbac.sha256sum] = "df31862fb3b18ef54aea6001a1fab9d51b0cbaedb6369ea188d981cd62a0e3bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libsss_nss_idmap-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libsss_nss_idmap;unpack=0"
SRC_URI[x86_64_v2_python3-libsss_nss_idmap.sha256sum] = "e2b60a7687ad9b9cc1356117e8b501be4eee3679ab6a079a5f8b4ffcc8b84fc0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-sss-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-sss;unpack=0"
SRC_URI[x86_64_v2_python3-sss.sha256sum] = "251e6dabcebbd16fc23c6de1237e5145ca9f1a810f25ac11a286b8fee8e65f32"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-sss-murmur-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-sss-murmur;unpack=0"
SRC_URI[x86_64_v2_python3-sss-murmur.sha256sum] = "fa6b11c9268988bebb7e28f2bcaf9c53f3a336db70a2a385cf927b1e10b0ad31"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-sssdconfig-2.13.1-3.el10.noarch.rpm;name=x86_64_v2_python3-sssdconfig;unpack=0"
SRC_URI[x86_64_v2_python3-sssdconfig.sha256sum] = "60fde2b3680fdf6c8c2fcfe91f9c2123923ca87ada0b70da696f0e5398d6d4bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd;unpack=0"
SRC_URI[x86_64_v2_sssd.sha256sum] = "e0a60c1f27717693ec1c5f3509210e07955ea1a92ebc78d399d3ac0ae1264568"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-ad-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-ad;unpack=0"
SRC_URI[x86_64_v2_sssd-ad.sha256sum] = "c6d0944df9d6f66d5f1640cb6a91ea5051cabfea734f65a6bec9f36118e95526"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-client-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-client;unpack=0"
SRC_URI[x86_64_v2_sssd-client.sha256sum] = "d97c54ef6d5b90a8e4bac02955d6b0e07610054498b4ce81f3fb1298b42db2ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-common-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-common;unpack=0"
SRC_URI[x86_64_v2_sssd-common.sha256sum] = "b460fcef4c1ed6642ac2233c6fb04eecc22d6c46a882896aa6f94fb840f9b0f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-common-pac-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-common-pac;unpack=0"
SRC_URI[x86_64_v2_sssd-common-pac.sha256sum] = "d12c70559abd55413143f48314549c34a08f385935273511c9b72955b6c7ca7a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-dbus-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-dbus;unpack=0"
SRC_URI[x86_64_v2_sssd-dbus.sha256sum] = "95f5f47bc98b1d2e98483bab8d8e245ed828b8c594ac98ee2a72f97b19da0916"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sssd-idp-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-idp;unpack=0"
SRC_URI[x86_64_v2_sssd-idp.sha256sum] = "6acb657bf62779232fd42cbc9e51e15da6c0b99e6d411f28a254cd4bd27bb33f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-ipa-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-ipa;unpack=0"
SRC_URI[x86_64_v2_sssd-ipa.sha256sum] = "ebaac158ecb3c9551cdf4d47fd8982feeed1f73ae830ed033a880483e5b316be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-kcm-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-kcm;unpack=0"
SRC_URI[x86_64_v2_sssd-kcm.sha256sum] = "10c1bebc2d3100ddeb8c4aaea9a898b8d64c568c786c76ebe8ef3e969340dc4d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-krb5-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-krb5;unpack=0"
SRC_URI[x86_64_v2_sssd-krb5.sha256sum] = "1b5c0cabf2d3f08834247a3478efa11d3f8c69c64d12383459b1e8fcfe8a2ac3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-krb5-common-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-krb5-common;unpack=0"
SRC_URI[x86_64_v2_sssd-krb5-common.sha256sum] = "21e8a24437c270650da643ef85bccc970465d32d170cdcbab83bf1e06114f623"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-ldap-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-ldap;unpack=0"
SRC_URI[x86_64_v2_sssd-ldap.sha256sum] = "0ce9a14c694039eaafdadf82da97d14380eeb1b7529a8e3507830d48fb9dddcc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-nfs-idmap-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-nfs-idmap;unpack=0"
SRC_URI[x86_64_v2_sssd-nfs-idmap.sha256sum] = "bf9a1e8ce2e181f038f3b6c421b85cc217d9bd10d6c33e2532bcd7e88d2c156b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-passkey-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-passkey;unpack=0"
SRC_URI[x86_64_v2_sssd-passkey.sha256sum] = "b5c029f539ce873ccbe54dd4ae1e9623af5f04bdd2e7ae2e2fe98ff365ef8a5d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-proxy-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-proxy;unpack=0"
SRC_URI[x86_64_v2_sssd-proxy.sha256sum] = "9bcaebb9ea5171de2483e16f38d9b24818b5b67b98f41d53e34eee2f3b0afbb3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-tools-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-tools;unpack=0"
SRC_URI[x86_64_v2_sssd-tools.sha256sum] = "aed12d60579b1f55bf4a949b8431429a0a903c11d6d78b191d932185fe3837b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-winbind-idmap-2.13.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-winbind-idmap;unpack=0"
SRC_URI[x86_64_v2_sssd-winbind-idmap.sha256sum] = "cd3b208f69ecb3dc46ec7df0d14606240fea18d86cb36cf3ee9ce7b028e43ddf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libipa_hbac-2.13.1-3.el10.aarch64.rpm;name=aarch64_libipa_hbac;unpack=0"
SRC_URI[aarch64_libipa_hbac.sha256sum] = "bca375e15aa841df31e115b5b1ab7d025eb4e60d2a2450cf798bb07a129f0c59"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_autofs-2.13.1-3.el10.aarch64.rpm;name=aarch64_libsss_autofs;unpack=0"
SRC_URI[aarch64_libsss_autofs.sha256sum] = "826dc9306256803b546dc123173efb857600d0ed9485b61d33c3af53f59ace88"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_certmap-2.13.1-3.el10.aarch64.rpm;name=aarch64_libsss_certmap;unpack=0"
SRC_URI[aarch64_libsss_certmap.sha256sum] = "aed155c428ff87129f9227c0dbb4e174b57767750a7da18c8ad67f59172e5ffc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_idmap-2.13.1-3.el10.aarch64.rpm;name=aarch64_libsss_idmap;unpack=0"
SRC_URI[aarch64_libsss_idmap.sha256sum] = "8605a33004ff04956e98504572c012dc1035cdf48b3c428422ffc3ddf0630c0d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_nss_idmap-2.13.1-3.el10.aarch64.rpm;name=aarch64_libsss_nss_idmap;unpack=0"
SRC_URI[aarch64_libsss_nss_idmap.sha256sum] = "25eed17105982d2d568cee551679603b82e5f5b7feef52c0f555ecf88966549e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsss_nss_idmap-devel-2.13.1-3.el10.aarch64.rpm;name=aarch64_libsss_nss_idmap-devel;unpack=0"
SRC_URI[aarch64_libsss_nss_idmap-devel.sha256sum] = "d19df32b875998e8080ab5d83305b5cb75aa963290bb3f1b15045c76529e1048"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_sudo-2.13.1-3.el10.aarch64.rpm;name=aarch64_libsss_sudo;unpack=0"
SRC_URI[aarch64_libsss_sudo.sha256sum] = "dc3e6bdfe99711692d51fee6a60d773460993608d5c8a66ae87283e175e180b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libipa_hbac-2.13.1-3.el10.aarch64.rpm;name=aarch64_python3-libipa_hbac;unpack=0"
SRC_URI[aarch64_python3-libipa_hbac.sha256sum] = "2fe120696eac496a407536ca53d0e3e75e9eb3f0eb51f2668f97fe0457dfdce4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libsss_nss_idmap-2.13.1-3.el10.aarch64.rpm;name=aarch64_python3-libsss_nss_idmap;unpack=0"
SRC_URI[aarch64_python3-libsss_nss_idmap.sha256sum] = "07d3ef6e6ff04284c1a3e15873422adbdb81f3d50baa8573eee7a30079c7dbe2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-sss-2.13.1-3.el10.aarch64.rpm;name=aarch64_python3-sss;unpack=0"
SRC_URI[aarch64_python3-sss.sha256sum] = "d7f4f3573b6abb5574322d936ba88a9b730066fa6c75fd3dfc4d913726f3d01a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-sss-murmur-2.13.1-3.el10.aarch64.rpm;name=aarch64_python3-sss-murmur;unpack=0"
SRC_URI[aarch64_python3-sss-murmur.sha256sum] = "302aa8e4030aa8257a738f47d38fcabe7b5be14800dee8729493695f97eb1439"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-sssdconfig-2.13.1-3.el10.noarch.rpm;name=aarch64_python3-sssdconfig;unpack=0"
SRC_URI[aarch64_python3-sssdconfig.sha256sum] = "60fde2b3680fdf6c8c2fcfe91f9c2123923ca87ada0b70da696f0e5398d6d4bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd;unpack=0"
SRC_URI[aarch64_sssd.sha256sum] = "928b4723419496fec51a2e1188a35e56d0a3939abae028e1cc9a157fffba2a80"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-ad-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-ad;unpack=0"
SRC_URI[aarch64_sssd-ad.sha256sum] = "5edc346e03830e2a3807ecadf1b2017f1541ea6e11ec80d3d374a5f10d66056f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-client-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-client;unpack=0"
SRC_URI[aarch64_sssd-client.sha256sum] = "02960c08d10ad9aea87b5e8f31ccc350a3af3014e8b690ee2d0d3d9ad43f1df4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-common-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-common;unpack=0"
SRC_URI[aarch64_sssd-common.sha256sum] = "0d43d87a3e508fe69ed0d9aae2a49d34e0f21e4c07e39c1af1d43700a13d12e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-common-pac-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-common-pac;unpack=0"
SRC_URI[aarch64_sssd-common-pac.sha256sum] = "3785d28b8296a7c82d743296a95940750e2833e7f872ff65bcc96e5685679cd6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-dbus-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-dbus;unpack=0"
SRC_URI[aarch64_sssd-dbus.sha256sum] = "29c5933b17e76ff81506c8490088ff0daddade97e4a96906eafc3ee1e082a83d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sssd-idp-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-idp;unpack=0"
SRC_URI[aarch64_sssd-idp.sha256sum] = "a18bfac21c0711b525d1d7a2e06d398c8c9909e56fcd00b1cbdd0c8a35321f2d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-ipa-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-ipa;unpack=0"
SRC_URI[aarch64_sssd-ipa.sha256sum] = "91a8fed4fd90090cd566bed6bc3b1eb89674d38e8c4aeed9a938eb3763484ac5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-kcm-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-kcm;unpack=0"
SRC_URI[aarch64_sssd-kcm.sha256sum] = "f74462a99df71e7e909a0d769cbe7628575a65f5887e3755a17892a4ef331954"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-krb5-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-krb5;unpack=0"
SRC_URI[aarch64_sssd-krb5.sha256sum] = "fad5bf8a0d1c0025ec57c2ce6d5a9ae252d5836b90921d5a1d9b114b8a4c852f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-krb5-common-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-krb5-common;unpack=0"
SRC_URI[aarch64_sssd-krb5-common.sha256sum] = "d0afba72128dd83f8f757a46281e34ce361d7fab94be7e07b1073f600232772a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-ldap-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-ldap;unpack=0"
SRC_URI[aarch64_sssd-ldap.sha256sum] = "834771507d932748707600e037b4113dcd4f0e8e98ac6ae0557297b53223c0e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-nfs-idmap-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-nfs-idmap;unpack=0"
SRC_URI[aarch64_sssd-nfs-idmap.sha256sum] = "72f0a02781aaaaee7cc5f4dbb41cb0b8ceb06fda7add46a96130e157338c0174"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-passkey-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-passkey;unpack=0"
SRC_URI[aarch64_sssd-passkey.sha256sum] = "1133807c420e4f5e2ebebf6f2066368dceba17663343d5b2c282d7a490247343"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-proxy-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-proxy;unpack=0"
SRC_URI[aarch64_sssd-proxy.sha256sum] = "1c09a22d147ee6caa5b0b161dfdb6b59789b1c29ce743866dac0ad5db7913b19"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-tools-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-tools;unpack=0"
SRC_URI[aarch64_sssd-tools.sha256sum] = "958d7b84c5ba3700b3d986ab1d9555dc19ec42389097386b18900cc93a4f3499"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-winbind-idmap-2.13.1-3.el10.aarch64.rpm;name=aarch64_sssd-winbind-idmap;unpack=0"
SRC_URI[aarch64_sssd-winbind-idmap.sha256sum] = "6985d25177fda2fc98238503d6d5645189c1de97d5259f44997da4cd82cd682e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libipa_hbac-2.13.1-3.el10.riscv64.rpm;name=riscv64_libipa_hbac;unpack=0"
SRC_URI[riscv64_libipa_hbac.sha256sum] = "f37cf93a7cc1665baf1bf09b07b09a25597ed2d4c12d203be248d663e273a17f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libsss_autofs-2.13.1-3.el10.riscv64.rpm;name=riscv64_libsss_autofs;unpack=0"
SRC_URI[riscv64_libsss_autofs.sha256sum] = "872c6ca751c45ac48eb4ec30f197b5fe59aa74e5b3fb5a57e3237a9115cd4765"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libsss_certmap-2.13.1-3.el10.riscv64.rpm;name=riscv64_libsss_certmap;unpack=0"
SRC_URI[riscv64_libsss_certmap.sha256sum] = "bf4e4bcc1359e5c7b40956f43036fcf692a23dfb8f8250c2b6c6a7d771f7222b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libsss_idmap-2.13.1-3.el10.riscv64.rpm;name=riscv64_libsss_idmap;unpack=0"
SRC_URI[riscv64_libsss_idmap.sha256sum] = "e494e9754d5b2e5a09ae20a70c552292bb9dbc5db35e361481e8e8cbe3b4cf0a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libsss_nss_idmap-2.13.1-3.el10.riscv64.rpm;name=riscv64_libsss_nss_idmap;unpack=0"
SRC_URI[riscv64_libsss_nss_idmap.sha256sum] = "be7d9d673941d6f1b3ecde0b6d2ed7387ba2e4be7c503bc1137d25088511e4be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/libsss_nss_idmap-devel-2.13.1-3.el10.riscv64.rpm;name=riscv64_libsss_nss_idmap-devel;unpack=0"
SRC_URI[riscv64_libsss_nss_idmap-devel.sha256sum] = "9b4a84c00ec8ddecffe585e2e0c705e80f87a165204a978e55139376fe17529b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libsss_sudo-2.13.1-3.el10.riscv64.rpm;name=riscv64_libsss_sudo;unpack=0"
SRC_URI[riscv64_libsss_sudo.sha256sum] = "38238f70c173eed050aa2ebf6ee057a8146cafae491dc4f004f61567a0a1ab1e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/python3-libipa_hbac-2.13.1-3.el10.riscv64.rpm;name=riscv64_python3-libipa_hbac;unpack=0"
SRC_URI[riscv64_python3-libipa_hbac.sha256sum] = "2b2d35f1faa23ce5188518f9dac0a62b2b7c9407bd6a0d1275cab8a81c07b2a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/python3-libsss_nss_idmap-2.13.1-3.el10.riscv64.rpm;name=riscv64_python3-libsss_nss_idmap;unpack=0"
SRC_URI[riscv64_python3-libsss_nss_idmap.sha256sum] = "4b9a9000003986464ba13c4135070a96060f99d3652b7f6f5e3fa04087585d88"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/python3-sss-2.13.1-3.el10.riscv64.rpm;name=riscv64_python3-sss;unpack=0"
SRC_URI[riscv64_python3-sss.sha256sum] = "90337419827f8c3631693b2c2e4e82382dffe04d874a41f09433d58dbbad5108"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/python3-sss-murmur-2.13.1-3.el10.riscv64.rpm;name=riscv64_python3-sss-murmur;unpack=0"
SRC_URI[riscv64_python3-sss-murmur.sha256sum] = "05b65a75d30bd8f6ed35e4bb8fe345ea2e2507076dda81d79b22c5d8c2942de1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/python3-sssdconfig-2.13.1-3.el10.noarch.rpm;name=riscv64_python3-sssdconfig;unpack=0"
SRC_URI[riscv64_python3-sssdconfig.sha256sum] = "60fde2b3680fdf6c8c2fcfe91f9c2123923ca87ada0b70da696f0e5398d6d4bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd;unpack=0"
SRC_URI[riscv64_sssd.sha256sum] = "5b31c3da42a6bab4c5ab4ce48d8ffcbe46056f39dc6d53f7ae170457e859c03a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-ad-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-ad;unpack=0"
SRC_URI[riscv64_sssd-ad.sha256sum] = "86411d08c098e028231fc23d55af536e829757f5abd8da2f53cc4faeaec68084"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-client-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-client;unpack=0"
SRC_URI[riscv64_sssd-client.sha256sum] = "c7de1931a2eed08f0b66ecda8abcd7ea1448ae8c798c989a5cf8545ec30ab0a0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-common-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-common;unpack=0"
SRC_URI[riscv64_sssd-common.sha256sum] = "22c3e76a4dd54476fb4c7b6efc2dc027e88d4cbd1880ada4eabea33b02c2039c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-common-pac-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-common-pac;unpack=0"
SRC_URI[riscv64_sssd-common-pac.sha256sum] = "1dc45e21a55a4104584d7015a5335597ec80143ddb5da1a782d4be117388c942"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-dbus-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-dbus;unpack=0"
SRC_URI[riscv64_sssd-dbus.sha256sum] = "c6d94fa94aea933c6784e81604cce49c04fa3cf1447cd61bc0e0bc39b9052279"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/sssd-idp-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-idp;unpack=0"
SRC_URI[riscv64_sssd-idp.sha256sum] = "2784b117e0e57d4737def1256b8e6010d6038fff18dcb9c760074dca6379b566"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-ipa-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-ipa;unpack=0"
SRC_URI[riscv64_sssd-ipa.sha256sum] = "2be801b478003f7b3a1d3e8c7d183a12238680fa6a85b0254b5e28f1a0c660c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-kcm-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-kcm;unpack=0"
SRC_URI[riscv64_sssd-kcm.sha256sum] = "ae5f7a4bff5a3d3d966cbebf5a78bd31a8b9a9f5acbc605e01317911dceb0e6b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-krb5-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-krb5;unpack=0"
SRC_URI[riscv64_sssd-krb5.sha256sum] = "db8aac6706c778e5b4e0e7e1ad9136595112d159753ce58b3a8143d53893baa4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-krb5-common-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-krb5-common;unpack=0"
SRC_URI[riscv64_sssd-krb5-common.sha256sum] = "ed40460803995717cf27e631ab146a8a47bf77c6f56edc2cf7eae408bb4ad359"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-ldap-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-ldap;unpack=0"
SRC_URI[riscv64_sssd-ldap.sha256sum] = "1bcfd4a63c2d7bd4df52d9c5dfab8f990eea17e882d44e498c0cc6398185154a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-nfs-idmap-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-nfs-idmap;unpack=0"
SRC_URI[riscv64_sssd-nfs-idmap.sha256sum] = "5c432ff868819243cfb908ec3616479021a041fea44a8d996602f35ee2b3a764"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-passkey-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-passkey;unpack=0"
SRC_URI[riscv64_sssd-passkey.sha256sum] = "3a99e0d07983051d3aaa730d430f5bc318f84300eeb752fb1898c9a2d10a14b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-proxy-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-proxy;unpack=0"
SRC_URI[riscv64_sssd-proxy.sha256sum] = "3b9ce89f40852f4003370b070d0d082d8bf06de2aae26b1acb1a54d156506e41"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-tools-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-tools;unpack=0"
SRC_URI[riscv64_sssd-tools.sha256sum] = "471b02217369f35f1997452ccd72d4db9c483c819a5739fce4f5e30bbb3832a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/sssd-winbind-idmap-2.13.1-3.el10.riscv64.rpm;name=riscv64_sssd-winbind-idmap;unpack=0"
SRC_URI[riscv64_sssd-winbind-idmap.sha256sum] = "5e1abc0b5805790b5c5f125d2757052e2b10590fb7823d561be83ebe0264ae9b"

RDEPENDS:libipa_hbac = " \
 glibc \
 libunistring \
 "
RDEPENDS:libsss_autofs = " \
 glibc \
 "
RDEPENDS:libsss_certmap = " \
 glibc \
 libtalloc \
 openssl-libs \
 "
RDEPENDS:libsss_idmap = " \
 glibc \
 libunistring \
 "
RDEPENDS:libsss_nss_idmap = " \
 glibc \
 "
RDEPENDS:libsss_nss_idmap-devel = " \
 libsss_nss_idmap \
 pkgconf-pkg-config \
 "
RDEPENDS:libsss_sudo = " \
 glibc \
 "
RDEPENDS:python3-libipa_hbac = " \
 glibc \
 libipa_hbac \
 libunistring \
 python3 \
 "
RDEPENDS:python3-libsss_nss_idmap = " \
 glibc \
 libsss_nss_idmap \
 python3 \
 "
RDEPENDS:python3-sss:x86_64_v2 = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcap \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 python3 \
 sssd-common \
 systemd-libs \
"
RDEPENDS:python3-sss:aarch64 = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 python3 \
 sssd-common \
 systemd-libs \
"
RDEPENDS:python3-sss:riscv64 = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 python3 \
 sssd-common \
 systemd-libs \
"
RDEPENDS:python3-sss-murmur = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-sssdconfig = " \
 python3 \
 "
RDEPENDS:sssd = " \
 shadow-utils \
 sssd-ad \
 sssd-common \
 sssd-ipa \
 sssd-krb5 \
 sssd-ldap \
 sssd-proxy \
 "
RDEPENDS:sssd-ad:x86_64_v2 = " \
 cyrus-sasl-lib \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsmbclient \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-ad:aarch64 = " \
 cyrus-sasl-lib \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsmbclient \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-ad:riscv64 = " \
 cyrus-sasl-lib \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsmbclient \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-client = " \
 alternatives \
 bash \
 glibc \
 krb5-libs \
 libcom_err \
 libsss_idmap \
 libsss_nss_idmap \
 libunistring \
 pam-libs \
 "
RDEPENDS:sssd-common:x86_64_v2 = " \
 bash \
 c-ares \
 dbus-libs \
 glibc \
 jansson \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libnl3 \
 libref_array \
 libselinux \
 libsss_autofs \
 libsss_certmap \
 libsss_idmap \
 libsss_sudo \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 p11-kit \
 pam-libs \
 pcre2 \
 popt \
 samba-ndr-libs \
 shadow-utils \
 sssd-client \
 sssd-nfs-idmap \
 systemd \
 systemd-libs \
 virtual/coreutils \
"
RDEPENDS:sssd-common:aarch64 = " \
 bash \
 c-ares \
 dbus-libs \
 glibc \
 jansson \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libnl3 \
 libref_array \
 libselinux \
 libsss_autofs \
 libsss_certmap \
 libsss_idmap \
 libsss_sudo \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 p11-kit \
 pam-libs \
 pcre2 \
 popt \
 samba-ndr-libs \
 shadow-utils \
 sssd-client \
 sssd-nfs-idmap \
 systemd \
 systemd-libs \
 virtual/coreutils \
"
RDEPENDS:sssd-common:riscv64 = " \
 bash \
 c-ares \
 dbus-libs \
 glibc \
 jansson \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libnl3 \
 libref_array \
 libselinux \
 libsss_autofs \
 libsss_certmap \
 libsss_idmap \
 libsss_sudo \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 p11-kit \
 pam-libs \
 pcre2 \
 popt \
 samba-ndr-libs \
 shadow-utils \
 sssd-client \
 sssd-nfs-idmap \
 systemd \
 systemd-libs \
 virtual/coreutils \
"
RDEPENDS:sssd-common-pac = " \
 glibc \
 libldb \
 libselinux \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 popt \
 samba-ndr-libs \
 sssd-common \
 systemd-libs \
 "
RDEPENDS:sssd-dbus = " \
 bash \
 dbus-libs \
 glibc \
 libdhash \
 libldb \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 popt \
 sssd-common \
 systemd \
 systemd-libs \
 "
RDEPENDS:sssd-idp:x86_64_v2 = " \
 dbus-libs \
 glibc \
 jansson \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libjose \
 libldb \
 libref_array \
 libselinux \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 libuuid \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:sssd-idp:aarch64 = " \
 dbus-libs \
 glibc \
 jansson \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libjose \
 libldb \
 libref_array \
 libselinux \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 libuuid \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:sssd-idp:riscv64 = " \
 dbus-libs \
 glibc \
 jansson \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libjose \
 libldb \
 libref_array \
 libselinux \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 libuuid \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:sssd-ipa:x86_64_v2 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libipa_hbac \
 libldb \
 libref_array \
 libselinux \
 libsemanage \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-ipa:aarch64 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libipa_hbac \
 libldb \
 libref_array \
 libselinux \
 libsemanage \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-ipa:riscv64 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libipa_hbac \
 libldb \
 libref_array \
 libselinux \
 libsemanage \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-kcm = " \
 bash \
 glibc \
 krb5-libs \
 libdhash \
 libldb \
 libselinux \
 libtalloc \
 libtevent \
 libuuid \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd \
 systemd-libs \
 "
RDEPENDS:sssd-krb5:x86_64_v2 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-krb5:aarch64 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-krb5:riscv64 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-krb5-common:x86_64_v2 = " \
 cyrus-sasl-gssapi \
 glibc \
 jansson \
 krb5-libs \
 libcap \
 libtalloc \
 popt \
 sssd-common \
 systemd-libs \
"
RDEPENDS:sssd-krb5-common:aarch64 = " \
 cyrus-sasl-gssapi \
 glibc \
 jansson \
 krb5-libs \
 libtalloc \
 popt \
 sssd-common \
 systemd-libs \
"
RDEPENDS:sssd-krb5-common:riscv64 = " \
 cyrus-sasl-gssapi \
 glibc \
 jansson \
 krb5-libs \
 libtalloc \
 popt \
 sssd-common \
 systemd-libs \
"
RDEPENDS:sssd-ldap:x86_64_v2 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-ldap:aarch64 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-ldap:riscv64 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-nfs-idmap = " \
 glibc \
 libnfsidmap \
 "
RDEPENDS:sssd-passkey = " \
 acl \
 glibc \
 jansson \
 krb5-libs \
 libcom_err \
 libfido2 \
 libtalloc \
 openssl-libs \
 popt \
 sssd-common \
 "
RDEPENDS:sssd-proxy:x86_64_v2 = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcap \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pam-libs \
 pcre2 \
 popt \
 sssd-common \
 systemd-libs \
"
RDEPENDS:sssd-proxy:aarch64 = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pam-libs \
 pcre2 \
 popt \
 sssd-common \
 systemd-libs \
"
RDEPENDS:sssd-proxy:riscv64 = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pam-libs \
 pcre2 \
 popt \
 sssd-common \
 systemd-libs \
"
RDEPENDS:sssd-tools = " \
 bash \
 glibc \
 libdhash \
 libldb \
 libref_array \
 libsss_certmap \
 libtalloc \
 pam-libs \
 popt \
 python3 \
 python3-sss \
 python3-sssdconfig \
 python3-systemd \
 sssd-common \
 sssd-dbus \
 "
RDEPENDS:sssd-winbind-idmap = " \
 glibc \
 libsss_idmap \
 libsss_nss_idmap \
 libtalloc \
 libunistring \
 "
