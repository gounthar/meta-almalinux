# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sanlock"
PV = "5.1.0"
PR = "3.el10"
PACKAGES = " \
 sanlock \
 sanlock-devel \
 sanlock-lib \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sanlock-5.1.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a86e61d5c73db156952375fb9b0ec4cff4c500eb5a6c0a70d29cefb1e37e752c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sanlock-5.1.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_sanlock;unpack=0"
SRC_URI[x86_64_v2_sanlock.sha256sum] = "5ecb036ee1a0b35d504222f3f43d22dab36f0caed640139bed437b916957e2ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/sanlock-devel-5.1.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_sanlock-devel;unpack=0"
SRC_URI[x86_64_v2_sanlock-devel.sha256sum] = "ef6a44cefa413b3b029e846247fbe52016a0274d6cb73c6b9b9e75fd982ee221"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sanlock-lib-5.1.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_sanlock-lib;unpack=0"
SRC_URI[x86_64_v2_sanlock-lib.sha256sum] = "15081273b9eb7c9b5b9af06ecf519465fb407fc5f4cb555382d963cb38ea0fb3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sanlock-5.1.0-3.el10.aarch64.rpm;name=aarch64_sanlock;unpack=0"
SRC_URI[aarch64_sanlock.sha256sum] = "a0eaf8838a85e8db257882abb2550141140f0e7511fe76497a733b99f69c6a8b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/sanlock-devel-5.1.0-3.el10.aarch64.rpm;name=aarch64_sanlock-devel;unpack=0"
SRC_URI[aarch64_sanlock-devel.sha256sum] = "e538da577c6b9980afb1a30fb4508623a471bdecd72a57cb9fa80896d4fcc97c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sanlock-lib-5.1.0-3.el10.aarch64.rpm;name=aarch64_sanlock-lib;unpack=0"
SRC_URI[aarch64_sanlock-lib.sha256sum] = "0333090c51157dddfc46a516dfb4ffb65226d4e7f09faa922a7b727101fcd8f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/sanlock-5.1.0-3.el10.riscv64.rpm;name=riscv64_sanlock;unpack=0"
SRC_URI[riscv64_sanlock.sha256sum] = "b839727237b3bba9522bcab725b1a286f1c94743097eb4e2229b868e5e39d3d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/sanlock-devel-5.1.0-3.el10.riscv64.rpm;name=riscv64_sanlock-devel;unpack=0"
SRC_URI[riscv64_sanlock-devel.sha256sum] = "dbed1f7bd001b03cf7d969e18589ac3ea0f7f9f1176133b2b109400b79026c1e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/sanlock-lib-5.1.0-3.el10.riscv64.rpm;name=riscv64_sanlock-lib;unpack=0"
SRC_URI[riscv64_sanlock-lib.sha256sum] = "86b9a6afbc0eb3c19c4fa9f34f53631826c3052702b5512ad4dcff0444df3a17"

RDEPENDS:sanlock = " \
 bash \
 device-mapper-libs \
 glibc \
 libaio \
 libblkid \
 libuuid \
 sanlock-lib \
 systemd \
 "
RDEPENDS:sanlock-devel = " \
 pkgconf-pkg-config \
 sanlock-lib \
 "
RDEPENDS:sanlock-lib = " \
 device-mapper-libs \
 glibc \
 libaio \
 libblkid \
 "
