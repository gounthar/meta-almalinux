# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "brotli"
PV = "1.1.0"
PR = "8.el10"
PACKAGES = " \
 brotli \
 brotli-devel \
 libbrotli \
 python3-brotli \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/brotli-1.1.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c65190ae91e52bbb92623266e1a7eec5aad15b9a50199c253efc2cc28b9a621d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brotli-1.1.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_brotli;unpack=0"
SRC_URI[x86_64_v2_brotli.sha256sum] = "46b2e70fa070e9ecb081b3aa00f524f45f351da50fee3c1697734d999f7a17f5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brotli-devel-1.1.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_brotli-devel;unpack=0"
SRC_URI[x86_64_v2_brotli-devel.sha256sum] = "5a6ece5a504ac2a78369d12036e687aa418cf1bc44e03a3e141b90ca8c8ea4da"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libbrotli-1.1.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_libbrotli;unpack=0"
SRC_URI[x86_64_v2_libbrotli.sha256sum] = "3cafd6cbc2de69f4306c03655c0465c6a5b54c5687266267cbd59a417c56d346"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-brotli-1.1.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_python3-brotli;unpack=0"
SRC_URI[x86_64_v2_python3-brotli.sha256sum] = "074646266b7dae10cd574284f0583829e1387d427b96129824129b01bbdd83a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brotli-1.1.0-8.el10.aarch64.rpm;name=aarch64_brotli;unpack=0"
SRC_URI[aarch64_brotli.sha256sum] = "6fc457ea3fe9aaeb5011ddac1622d72ac925f99dc8c8807a934b95c6c75126d3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brotli-devel-1.1.0-8.el10.aarch64.rpm;name=aarch64_brotli-devel;unpack=0"
SRC_URI[aarch64_brotli-devel.sha256sum] = "7736285efe557afde0e4d8de7fec29c8ac5ac149ae11ea862907c2fa718bfe0d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libbrotli-1.1.0-8.el10.aarch64.rpm;name=aarch64_libbrotli;unpack=0"
SRC_URI[aarch64_libbrotli.sha256sum] = "5b93a9e50968496c53a4a77af51660c308a03e80fd118e2406a69a569e148fe9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-brotli-1.1.0-8.el10.aarch64.rpm;name=aarch64_python3-brotli;unpack=0"
SRC_URI[aarch64_python3-brotli.sha256sum] = "8eca9f99cfbe201ee1e802f8928ab908530f80bc7ce458dc876437373fa03354"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/brotli-1.1.0-8.el10.riscv64.rpm;name=riscv64_brotli;unpack=0"
SRC_URI[riscv64_brotli.sha256sum] = "bfc38c3999206dc48b521a4ab1bc66280988d71aa2855989d5bcba4370471f08"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/brotli-devel-1.1.0-8.el10.riscv64.rpm;name=riscv64_brotli-devel;unpack=0"
SRC_URI[riscv64_brotli-devel.sha256sum] = "c48bbe7a9a515512506d96c4de6ae91f12c48e3569c58f701c4825e8c4fb65a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libbrotli-1.1.0-8.el10.riscv64.rpm;name=riscv64_libbrotli;unpack=0"
SRC_URI[riscv64_libbrotli.sha256sum] = "4ab8beb22e05b13644a235564e4a748d82303dac6a0ed72f11b570f7bc81f37f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/python3-brotli-1.1.0-8.el10.riscv64.rpm;name=riscv64_python3-brotli;unpack=0"
SRC_URI[riscv64_python3-brotli.sha256sum] = "82a539a72d7b104013e762e9616d82608ea09c225ede095ec19dfa7a169645ca"

RDEPENDS:brotli = " \
 glibc \
 libbrotli \
 "
RDEPENDS:brotli-devel = " \
 brotli \
 brotli-devel \
 libbrotli \
 pkgconf-pkg-config \
 "
RDEPENDS:libbrotli = " \
 glibc \
 "
RDEPENDS:python3-brotli = " \
 glibc \
 python3 \
 "
