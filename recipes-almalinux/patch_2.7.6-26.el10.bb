# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "patch"
PV = "2.7.6"
PR = "26.el10"
PACKAGES = " \
 patch \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/patch-2.7.6-26.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cebd8ef0f014e785c108483b962ea65be750f91d98d2e2941184a6774d880ec8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/patch-2.7.6-26.el10.x86_64_v2.rpm;name=x86_64_v2_patch;unpack=0"
SRC_URI[x86_64_v2_patch.sha256sum] = "846bc4b572b149918471edfdfe6fbd4cf0d5174f6e262ca24aee9177f62aae9e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/patch-2.7.6-26.el10.aarch64.rpm;name=aarch64_patch;unpack=0"
SRC_URI[aarch64_patch.sha256sum] = "e2b9344530e980e72aaab80f3eab37923a32cc50128208aa11ef936a90dfd3d0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/patch-2.7.6-26.el10.riscv64.rpm;name=riscv64_patch;unpack=0"
SRC_URI[riscv64_patch.sha256sum] = "12633b8777921bb79be87e2a4a6d90ff20eabf655ea1a8cf475dfb6b7310b9c2"

RDEPENDS:patch = " \
 ed \
 glibc \
 libattr \
 libselinux \
 "
