# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotconf"
PV = "1.3"
PR = "37.el10"
PACKAGES = " \
 dotconf \
 dotconf-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotconf-1.3-37.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f4e09819f4824f13f2cd190558e89ec0dde0ad2b80fa5afa448bc6fcd68ddbc6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotconf-1.3-37.el10.x86_64_v2.rpm;name=x86_64_v2_dotconf;unpack=0"
SRC_URI[x86_64_v2_dotconf.sha256sum] = "cff07c4c36a0275aebfdebd0d47512f978fc6b29e2bf87d04ea47f50ee372d9f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotconf-devel-1.3-37.el10.x86_64_v2.rpm;name=x86_64_v2_dotconf-devel;unpack=0"
SRC_URI[x86_64_v2_dotconf-devel.sha256sum] = "20da79294f1fe080a71dd793099b52f2b6a388d7683523dc9f5efc3f29783cc2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotconf-1.3-37.el10.aarch64.rpm;name=aarch64_dotconf;unpack=0"
SRC_URI[aarch64_dotconf.sha256sum] = "c42ee805903811e865f4d0ddb3d2e5909da62c7d95109aba0d1f5468137411bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotconf-devel-1.3-37.el10.aarch64.rpm;name=aarch64_dotconf-devel;unpack=0"
SRC_URI[aarch64_dotconf-devel.sha256sum] = "90787f0a149ba82d7b604cbd5720cfeea92831fd6beac78e347649dc82662f35"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/dotconf-1.3-37.el10.riscv64.rpm;name=riscv64_dotconf;unpack=0"
SRC_URI[riscv64_dotconf.sha256sum] = "239fa683fa122c95ebf5edde0ce791cc6e4260ff458ec89f6be0486517767856"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/dotconf-devel-1.3-37.el10.riscv64.rpm;name=riscv64_dotconf-devel;unpack=0"
SRC_URI[riscv64_dotconf-devel.sha256sum] = "dae8ae46cab1d5ead860393d61117b23a3a3c5e210cbf9f33bdd9e98fbd0a174"

RDEPENDS:dotconf = " \
 glibc \
 "
RDEPENDS:dotconf-devel = " \
 dotconf \
 pkgconf-pkg-config \
 "
