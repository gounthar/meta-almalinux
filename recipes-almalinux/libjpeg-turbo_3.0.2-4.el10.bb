# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libjpeg-turbo"
PV = "3.0.2"
PR = "4.el10"
PACKAGES = " \
 libjpeg-turbo \
 libjpeg-turbo-devel \
 libjpeg-turbo-utils \
 turbojpeg \
 turbojpeg-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libjpeg-turbo-3.0.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b5b86c33d06259116ccf3e39d365ad98320f93fe4b7f3cd051fe5accbefcfb9c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libjpeg-turbo-3.0.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_libjpeg-turbo;unpack=0"
SRC_URI[x86_64_v2_libjpeg-turbo.sha256sum] = "728508ad184277169cd63265cdcbf67bbe0f5bde3b0965172eae70edb4d5917e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libjpeg-turbo-devel-3.0.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_libjpeg-turbo-devel;unpack=0"
SRC_URI[x86_64_v2_libjpeg-turbo-devel.sha256sum] = "357d103110c330c358a6840620e61e1352f54aff7007025d4ae4ad12f421c872"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libjpeg-turbo-utils-3.0.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_libjpeg-turbo-utils;unpack=0"
SRC_URI[x86_64_v2_libjpeg-turbo-utils.sha256sum] = "f6e61cd3995c7a30269705527cc3b901b509c192af4fc5135d84fa14a12b3e99"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/turbojpeg-3.0.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_turbojpeg;unpack=0"
SRC_URI[x86_64_v2_turbojpeg.sha256sum] = "57757803c80e56f744c5e5035f861c6f906bc1e431d795f4fa010bbbecec6de6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/turbojpeg-devel-3.0.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_turbojpeg-devel;unpack=0"
SRC_URI[x86_64_v2_turbojpeg-devel.sha256sum] = "b47c738218b01bc45927b882d6ced19a5f9247ffe49475347a738479e0cbf4f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libjpeg-turbo-3.0.2-4.el10.aarch64.rpm;name=aarch64_libjpeg-turbo;unpack=0"
SRC_URI[aarch64_libjpeg-turbo.sha256sum] = "2feaff518e78e3395767c576a927386ecd057cb7dd407bab47e5402fb922b5a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libjpeg-turbo-devel-3.0.2-4.el10.aarch64.rpm;name=aarch64_libjpeg-turbo-devel;unpack=0"
SRC_URI[aarch64_libjpeg-turbo-devel.sha256sum] = "b6e7c31784fe3d8d7cb320bfa0784d040637fafbbeb729fb5736f3648f3f36ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libjpeg-turbo-utils-3.0.2-4.el10.aarch64.rpm;name=aarch64_libjpeg-turbo-utils;unpack=0"
SRC_URI[aarch64_libjpeg-turbo-utils.sha256sum] = "2707d7ce316fa1453a89a7b3929d154df8543bcce0cb4cef65b6ac3b59c12e06"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/turbojpeg-3.0.2-4.el10.aarch64.rpm;name=aarch64_turbojpeg;unpack=0"
SRC_URI[aarch64_turbojpeg.sha256sum] = "7757d72c3d98e41bfc6ba364b68539743c94f5d7cc99774ad1dad34c798b1394"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/turbojpeg-devel-3.0.2-4.el10.aarch64.rpm;name=aarch64_turbojpeg-devel;unpack=0"
SRC_URI[aarch64_turbojpeg-devel.sha256sum] = "25a17e87ae2d0e166e06c3b970e1558155c148bc6ec27311f2cdf1ac8392edb0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libjpeg-turbo-3.0.2-4.el10.riscv64.rpm;name=riscv64_libjpeg-turbo;unpack=0"
SRC_URI[riscv64_libjpeg-turbo.sha256sum] = "9ce6d32850f00ee37677c7740e41907324eeaa1c5a43b4b4f81a412df800f9f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libjpeg-turbo-devel-3.0.2-4.el10.riscv64.rpm;name=riscv64_libjpeg-turbo-devel;unpack=0"
SRC_URI[riscv64_libjpeg-turbo-devel.sha256sum] = "0735f888b51ddd86907ada7ae25089cd64a242664429cbdec02bd924ab18564d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libjpeg-turbo-utils-3.0.2-4.el10.riscv64.rpm;name=riscv64_libjpeg-turbo-utils;unpack=0"
SRC_URI[riscv64_libjpeg-turbo-utils.sha256sum] = "9a328fcf2c54757362a8a9000b29a8a103568e89c192dd18a0d035d5bbe72c35"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/turbojpeg-3.0.2-4.el10.riscv64.rpm;name=riscv64_turbojpeg;unpack=0"
SRC_URI[riscv64_turbojpeg.sha256sum] = "400d2883d2960d90415a2cd07616fe7f944469583eb82666b8ba9c65de07bbb4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/turbojpeg-devel-3.0.2-4.el10.riscv64.rpm;name=riscv64_turbojpeg-devel;unpack=0"
SRC_URI[riscv64_turbojpeg-devel.sha256sum] = "88a5a6e691cd6336f9b0832b9b5c178291fb173b5d62bec35083993329ed0f0a"

RDEPENDS:libjpeg-turbo = " \
 glibc \
 "
RDEPENDS:libjpeg-turbo-devel = " \
 cmake-filesystem \
 libjpeg-turbo \
 pkgconf-pkg-config \
 "
RDEPENDS:libjpeg-turbo-utils = " \
 glibc \
 libjpeg-turbo \
 "
RDEPENDS:turbojpeg = " \
 glibc \
 "
RDEPENDS:turbojpeg-devel = " \
 pkgconf-pkg-config \
 turbojpeg \
 "
