# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgexiv2"
PV = "0.14.3"
PR = "3.el10"
PACKAGES = " \
 libgexiv2 \
 libgexiv2-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libgexiv2-0.14.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e6292c059e3ee55dc1170b3a2669542ca7dbb3698869b8734b64954c485b400c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgexiv2-0.14.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_libgexiv2;unpack=0"
SRC_URI[x86_64_v2_libgexiv2.sha256sum] = "b036f2dbaa0c765100964714774dd02d11711e4a5e5f400b9bc7a15de3e34d71"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgexiv2-devel-0.14.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_libgexiv2-devel;unpack=0"
SRC_URI[x86_64_v2_libgexiv2-devel.sha256sum] = "aabb847d86edbc43c5e254ca88616a83d4f80ef71ca3451309efb899872ed80a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgexiv2-0.14.3-3.el10.aarch64.rpm;name=aarch64_libgexiv2;unpack=0"
SRC_URI[aarch64_libgexiv2.sha256sum] = "740d6a21ea6d19a6e8f551c146d881238cfe32a13637ce8c4dfd835d6b4d4dc2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgexiv2-devel-0.14.3-3.el10.aarch64.rpm;name=aarch64_libgexiv2-devel;unpack=0"
SRC_URI[aarch64_libgexiv2-devel.sha256sum] = "be7ebb3e1585f6d6070a317a7be11aff885e9944ca29cd885a4e6dd378e8eb23"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libgexiv2-0.14.3-3.el10.riscv64.rpm;name=riscv64_libgexiv2;unpack=0"
SRC_URI[riscv64_libgexiv2.sha256sum] = "e5e4c20d3d88584fda68c547d75b33dc950019df4287dc41e8b7df32d9b32956"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/libgexiv2-devel-0.14.3-3.el10.riscv64.rpm;name=riscv64_libgexiv2-devel;unpack=0"
SRC_URI[riscv64_libgexiv2-devel.sha256sum] = "5a51f451721fed7674af62be0df399efeb594f7608e48e5b4ff11b1b81ee3c10"

RDEPENDS:libgexiv2 = " \
 exiv2-libs \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libgexiv2-devel = " \
 exiv2-devel \
 glib2-devel \
 libgexiv2 \
 pkgconf-pkg-config \
 "
