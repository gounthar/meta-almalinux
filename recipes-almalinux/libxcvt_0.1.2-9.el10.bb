# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxcvt"
PV = "0.1.2"
PR = "9.el10"
PACKAGES = " \
 libxcvt \
 libxcvt-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libxcvt-0.1.2-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "830c31c81c128f3f6c0b5e4474ba16f7d7992d2eaba483324abeeb1a6bd54c71"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxcvt-0.1.2-9.el10.x86_64_v2.rpm;name=x86_64_v2_libxcvt;unpack=0"
SRC_URI[x86_64_v2_libxcvt.sha256sum] = "fce8fb8615256e6c7e8b88dd375d580ba3d97f3520155b59b025baba85c690a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxcvt-devel-0.1.2-9.el10.x86_64_v2.rpm;name=x86_64_v2_libxcvt-devel;unpack=0"
SRC_URI[x86_64_v2_libxcvt-devel.sha256sum] = "c1f4639f5b63f85f010101de22111645131f16d0d68db8fc9c7f21a10c45f128"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxcvt-0.1.2-9.el10.aarch64.rpm;name=aarch64_libxcvt;unpack=0"
SRC_URI[aarch64_libxcvt.sha256sum] = "e90ebf540fe863cd1f76a2fe7ac9d011fee3bb9b273cddc6e119fdd1632feec2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxcvt-devel-0.1.2-9.el10.aarch64.rpm;name=aarch64_libxcvt-devel;unpack=0"
SRC_URI[aarch64_libxcvt-devel.sha256sum] = "28ddb9d1b3c15d1899b85b889d852bfb337742f02a3e984c2733612e97d7d1f5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libxcvt-0.1.2-9.el10.riscv64.rpm;name=riscv64_libxcvt;unpack=0"
SRC_URI[riscv64_libxcvt.sha256sum] = "7b45dab3d71b5348164ade983be5d0b7cdb9339e0b9cc1ed6b2acd320f893af9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/libxcvt-devel-0.1.2-9.el10.riscv64.rpm;name=riscv64_libxcvt-devel;unpack=0"
SRC_URI[riscv64_libxcvt-devel.sha256sum] = "b4ace3693a879379cbf6e836685388061be8cbd842b75029484d71c87fec4f48"

RDEPENDS:libxcvt = " \
 glibc \
 "
RDEPENDS:libxcvt-devel = " \
 libxcvt \
 pkgconf-pkg-config \
 "
