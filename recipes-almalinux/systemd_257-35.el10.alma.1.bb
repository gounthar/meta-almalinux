# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "systemd"
PV = "257"
PR = "35.el10.alma.1"
PACKAGES = " \
 systemd \
 systemd-boot-unsigned \
 systemd-container \
 systemd-devel \
 systemd-journal-remote \
 systemd-libs \
 systemd-oomd \
 systemd-pam \
 systemd-resolved \
 systemd-rpm-macros \
 systemd-udev \
 systemd-ukify \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/systemd-257-35.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "52c6a8c085966d4b34dc7bd439e7dfc028b7f0882be275ebb035b2271ca65f63"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - systemd-container: libcap.so.2()(64bit)
# - systemd-libs: libcap.so.2()(64bit)
# - systemd-pam: libcap.so.2()(64bit)
# - systemd: libcap.so.2()(64bit)

## Requires (riscv64) that were seen as not satisfiable in original repo:
# - systemd-container: libcap.so.2()(64bit)
# - systemd-libs: libcap.so.2()(64bit)
# - systemd-pam: libcap.so.2()(64bit)
# - systemd-udev: (sdubby > 1.0-3 if sdubby)
# - systemd: libcap.so.2()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-257-35.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd;unpack=0"
SRC_URI[x86_64_v2_systemd.sha256sum] = "7f2f670e1ed1608d034ccb62c7b43cd185a6fc59a0ca1b2d79ce0587c647d805"
RPROVIDES:systemd:append:x86_64_v2 = " virtual/group_dialout_ virtual/group_tty_ virtual/syslog"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-boot-unsigned-257-35.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-boot-unsigned;unpack=0"
SRC_URI[x86_64_v2_systemd-boot-unsigned.sha256sum] = "bee26436899d890040274de22bf167bdbcfd6fe5223a5507e1d0650c8062589a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-container-257-35.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-container;unpack=0"
SRC_URI[x86_64_v2_systemd-container.sha256sum] = "b68dcfd494ffa324d6ff2854313db734bf792ae0d7f84bd8ad6d1dd79f573a60"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-devel-257-35.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-devel;unpack=0"
SRC_URI[x86_64_v2_systemd-devel.sha256sum] = "ead5e940c4e0138d02b6f8e8f334a8e73f7545038da9b8c4c7147b73360b6cad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-journal-remote-257-35.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-journal-remote;unpack=0"
SRC_URI[x86_64_v2_systemd-journal-remote.sha256sum] = "05dcaeeebc5dd724d55b7bdcdd0ac2969895abc34401b942deeeb71aa9a16d6d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-libs-257-35.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-libs;unpack=0"
SRC_URI[x86_64_v2_systemd-libs.sha256sum] = "cbac118d64d9e3c18cda00a94710c3b48933eef37a0c8254a020f1321d53302f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-oomd-257-35.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-oomd;unpack=0"
SRC_URI[x86_64_v2_systemd-oomd.sha256sum] = "8c015fd9e7984b8d807becbe3147941105bc2641480418ddbf177524cd3c6455"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-pam-257-35.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-pam;unpack=0"
SRC_URI[x86_64_v2_systemd-pam.sha256sum] = "a3d15fae37f8da06deb85ade2a571f61f1a695be6d224ba2146d3a2e6ae6a064"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-resolved-257-35.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-resolved;unpack=0"
SRC_URI[x86_64_v2_systemd-resolved.sha256sum] = "a1bd75156b9035bc086d89c0d1623c0d51678280beeae1f19becf0d4484e46c8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-rpm-macros-257-35.el10.alma.1.noarch.rpm;name=x86_64_v2_systemd-rpm-macros;unpack=0"
SRC_URI[x86_64_v2_systemd-rpm-macros.sha256sum] = "1acc9ee09ddaeba648767fd760ac304888218e7f0f2f19733b27fb01b1da64ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-udev-257-35.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-udev;unpack=0"
SRC_URI[x86_64_v2_systemd-udev.sha256sum] = "4da55e90f82b9d44b39cb007b76e165e015447529ab52862daa996b95f008e5a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-ukify-257-35.el10.alma.1.noarch.rpm;name=x86_64_v2_systemd-ukify;unpack=0"
SRC_URI[x86_64_v2_systemd-ukify.sha256sum] = "0520db511e9edf6022c66d595205fd12f1c848ff5f5c9bcfe65d956bbe31ae9d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-257-35.el10.alma.1.aarch64.rpm;name=aarch64_systemd;unpack=0"
SRC_URI[aarch64_systemd.sha256sum] = "fc3e78eb85d286c5c2781c21d238b10c482b6588bfca668d9a29e9dba4a7bee5"
RPROVIDES:systemd:append:aarch64 = " virtual/group_dialout_ virtual/group_tty_ virtual/syslog"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-boot-unsigned-257-35.el10.alma.1.aarch64.rpm;name=aarch64_systemd-boot-unsigned;unpack=0"
SRC_URI[aarch64_systemd-boot-unsigned.sha256sum] = "215421a5b8c5bd0fce018a8e17ed385a88ad0e144bf97e3df60e08ed31086ebf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-container-257-35.el10.alma.1.aarch64.rpm;name=aarch64_systemd-container;unpack=0"
SRC_URI[aarch64_systemd-container.sha256sum] = "e6310956300c819ef9bbf32071bd2c1523b73942d36bc0bd378948df8ad60b13"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-devel-257-35.el10.alma.1.aarch64.rpm;name=aarch64_systemd-devel;unpack=0"
SRC_URI[aarch64_systemd-devel.sha256sum] = "d6ea92aefb6109e8bddf2406d0db09acb78a5bb2703ec867dc2a99191a4004f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-journal-remote-257-35.el10.alma.1.aarch64.rpm;name=aarch64_systemd-journal-remote;unpack=0"
SRC_URI[aarch64_systemd-journal-remote.sha256sum] = "c9d320399d07999f3fc8e924243b9ee5e8fd66c1d2d6ce3222d2d18dd260d418"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-libs-257-35.el10.alma.1.aarch64.rpm;name=aarch64_systemd-libs;unpack=0"
SRC_URI[aarch64_systemd-libs.sha256sum] = "3a76eaa9be2f4a2d897f73ca36e23243c315e25ec94ddd01d5b7e48b46e371a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-oomd-257-35.el10.alma.1.aarch64.rpm;name=aarch64_systemd-oomd;unpack=0"
SRC_URI[aarch64_systemd-oomd.sha256sum] = "fea68df83d1ca9e935fae75f7e37808a6ab30218b926c5083b20ca494a6a5cf7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-pam-257-35.el10.alma.1.aarch64.rpm;name=aarch64_systemd-pam;unpack=0"
SRC_URI[aarch64_systemd-pam.sha256sum] = "bc4f87c6bb9be0a77e2c51677b6e9abfc9a328098fb4a21e1a3f1af1a83f334c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-resolved-257-35.el10.alma.1.aarch64.rpm;name=aarch64_systemd-resolved;unpack=0"
SRC_URI[aarch64_systemd-resolved.sha256sum] = "f9b545d92ad403a5dcc8e4791ef19c111c1aa82c80ea9957fd2e1b468c4846c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-rpm-macros-257-35.el10.alma.1.noarch.rpm;name=aarch64_systemd-rpm-macros;unpack=0"
SRC_URI[aarch64_systemd-rpm-macros.sha256sum] = "1acc9ee09ddaeba648767fd760ac304888218e7f0f2f19733b27fb01b1da64ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-udev-257-35.el10.alma.1.aarch64.rpm;name=aarch64_systemd-udev;unpack=0"
SRC_URI[aarch64_systemd-udev.sha256sum] = "160c32b0f2dfd27c9cd0c929b66b83b6bb62a7dd5a510a70651d0505ae2fd623"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-ukify-257-35.el10.alma.1.noarch.rpm;name=aarch64_systemd-ukify;unpack=0"
SRC_URI[aarch64_systemd-ukify.sha256sum] = "0520db511e9edf6022c66d595205fd12f1c848ff5f5c9bcfe65d956bbe31ae9d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/systemd-257-35.el10.alma.1.riscv64.rpm;name=riscv64_systemd;unpack=0"
SRC_URI[riscv64_systemd.sha256sum] = "8d9429fa433763ed0bc389ab7a477c0ddc552ab77ded62e7b0b90201f83ee4c5"
RPROVIDES:systemd:append:riscv64 = " virtual/syslog"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/systemd-boot-unsigned-257-35.el10.alma.1.riscv64.rpm;name=riscv64_systemd-boot-unsigned;unpack=0"
SRC_URI[riscv64_systemd-boot-unsigned.sha256sum] = "5535f57c730a19dfacfec32b3bbf2ac2471b51706328ce34dc7d88e73edd39fb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/systemd-container-257-35.el10.alma.1.riscv64.rpm;name=riscv64_systemd-container;unpack=0"
SRC_URI[riscv64_systemd-container.sha256sum] = "cdceca635996fb4f30d4c1b46fa2699c3c083c15dfd50937ea505ca699fd00e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/systemd-devel-257-35.el10.alma.1.riscv64.rpm;name=riscv64_systemd-devel;unpack=0"
SRC_URI[riscv64_systemd-devel.sha256sum] = "9fea4424b2acbb4b3a66bf3e30cd244eb4557a200c3e08d3d6fc5bf4467231eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/systemd-journal-remote-257-35.el10.alma.1.riscv64.rpm;name=riscv64_systemd-journal-remote;unpack=0"
SRC_URI[riscv64_systemd-journal-remote.sha256sum] = "d5e3902c9866bd6e7b24df58b8482c9e4925cff961bc6ec012bcb2e22ac39a04"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/systemd-libs-257-35.el10.alma.1.riscv64.rpm;name=riscv64_systemd-libs;unpack=0"
SRC_URI[riscv64_systemd-libs.sha256sum] = "053c328f8bfe0931de9d8fed3b01de4ab1f270b6cd1a7f9f3927038c4e6a4027"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/systemd-oomd-257-35.el10.alma.1.riscv64.rpm;name=riscv64_systemd-oomd;unpack=0"
SRC_URI[riscv64_systemd-oomd.sha256sum] = "608cfb37b51403382c17cdb50eb5c6891248a2c5b3c48705f3c590db051559be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/systemd-pam-257-35.el10.alma.1.riscv64.rpm;name=riscv64_systemd-pam;unpack=0"
SRC_URI[riscv64_systemd-pam.sha256sum] = "71a7cdbc772927ba933091b92701ae6776505529ce214b800a21466d326e80c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/systemd-resolved-257-35.el10.alma.1.riscv64.rpm;name=riscv64_systemd-resolved;unpack=0"
SRC_URI[riscv64_systemd-resolved.sha256sum] = "c59790b2494f232dec2cbed4760a868956f7794091fe2b9f9b1c2a4d687a32b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/systemd-rpm-macros-257-35.el10.alma.1.noarch.rpm;name=riscv64_systemd-rpm-macros;unpack=0"
SRC_URI[riscv64_systemd-rpm-macros.sha256sum] = "1acc9ee09ddaeba648767fd760ac304888218e7f0f2f19733b27fb01b1da64ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/systemd-udev-257-35.el10.alma.1.riscv64.rpm;name=riscv64_systemd-udev;unpack=0"
SRC_URI[riscv64_systemd-udev.sha256sum] = "997d9aa9d9353520577062ab6197518ac6e55c11ea9d15af098707ce18ecfdff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/systemd-ukify-257-35.el10.alma.1.noarch.rpm;name=riscv64_systemd-ukify;unpack=0"
SRC_URI[riscv64_systemd-ukify.sha256sum] = "0520db511e9edf6022c66d595205fd12f1c848ff5f5c9bcfe65d956bbe31ae9d"

RDEPENDS:systemd:x86_64_v2 = " \
 audit-libs \
 bash \
 bzip2-libs \
 dbus \
 glibc \
 grep \
 libacl \
 libblkid \
 libcap \
 libfdisk \
 libgcc \
 libmount \
 libseccomp \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 systemd-libs \
 systemd-pam \
 systemd-rpm-macros \
 virtual/coreutils \
 virtual/util-linux-core_or_util-linux \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:systemd:aarch64 = " \
 audit-libs \
 bash \
 bzip2-libs \
 dbus \
 glibc \
 grep \
 libacl \
 libblkid \
 libfdisk \
 libgcc \
 libmount \
 libseccomp \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 systemd-libs \
 systemd-pam \
 systemd-rpm-macros \
 virtual/coreutils \
 virtual/util-linux-core_or_util-linux \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:systemd:riscv64 = " \
 audit-libs \
 bash \
 bzip2-libs \
 dbus \
 glibc \
 grep \
 libacl \
 libblkid \
 libfdisk \
 libgcc \
 libmount \
 libseccomp \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 systemd-libs \
 systemd-pam \
 systemd-rpm-macros \
 virtual/coreutils \
 virtual/util-linux-core_or_util-linux \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:systemd-boot-unsigned = " \
 "
RDEPENDS:systemd-container:x86_64_v2 = " \
 bzip2-libs \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 openssl-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:systemd-container:aarch64 = " \
 bzip2-libs \
 glibc \
 libgcc \
 libseccomp \
 libselinux \
 openssl-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:systemd-container:riscv64 = " \
 bzip2-libs \
 glibc \
 libgcc \
 libseccomp \
 libselinux \
 openssl-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:systemd-devel = " \
 systemd-libs \
 systemd-rpm-macros \
 "
RDEPENDS:systemd-journal-remote = " \
 bash \
 firewalld-filesystem \
 glibc \
 libgcc \
 libmicrohttpd \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:systemd-libs:x86_64_v2 = " \
 glibc \
 libcap \
 libgcc \
"
RDEPENDS:systemd-libs:aarch64 = " \
 glibc \
 libgcc \
"
RDEPENDS:systemd-libs:riscv64 = " \
 glibc \
 libgcc \
"
RDEPENDS:systemd-oomd = " \
 bash \
 glibc \
 libgcc \
 systemd \
 systemd-udev \
 "
RDEPENDS:systemd-pam:x86_64_v2 = " \
 glibc \
 libcap \
 libgcc \
 pam-libs \
 systemd \
"
RDEPENDS:systemd-pam:aarch64 = " \
 glibc \
 libgcc \
 pam-libs \
 systemd \
"
RDEPENDS:systemd-pam:riscv64 = " \
 glibc \
 libgcc \
 pam-libs \
 systemd \
"
RDEPENDS:systemd-resolved = " \
 bash \
 glibc \
 grep \
 libgcc \
 libidn2 \
 openssl-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:systemd-rpm-macros = " \
 bash \
 "
RDEPENDS:systemd-udev:x86_64_v2 = " \
 bash \
 cryptsetup-libs \
 glibc \
 grep \
 grubby \
 kbd \
 kmod \
 kmod-libs \
 libblkid \
 libfdisk \
 libgcc \
 openssl-libs \
 sdubby \
 systemd \
"
RDEPENDS:systemd-udev:aarch64 = " \
 bash \
 cryptsetup-libs \
 glibc \
 grep \
 grubby \
 kbd \
 kmod \
 kmod-libs \
 libblkid \
 libfdisk \
 libgcc \
 openssl-libs \
 sdubby \
 systemd \
"
RDEPENDS:systemd-udev:riscv64 = " \
 bash \
 cryptsetup-libs \
 glibc \
 grep \
 grubby \
 kbd \
 kmod \
 kmod-libs \
 libblkid \
 libfdisk \
 libgcc \
 openssl-libs \
 systemd \
"
RDEPENDS:systemd-ukify = " \
 python3 \
 python3-cryptography \
 python3-pefile \
 python3-zstandard \
 systemd \
 systemd-boot-unsigned \
 "
