# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "greenboot-rs"
PV = "0.16.4"
PR = "0.el10"
PACKAGES = " \
 greenboot \
 greenboot-default-health-checks \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/greenboot-rs-0.16.4-0.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "52bea9e3b603f21cf6fe05a9c09b5909643f575f2df157587cc608b131b1b13b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/greenboot-0.16.4-0.el10.x86_64_v2.rpm;name=x86_64_v2_greenboot;unpack=0"
SRC_URI[x86_64_v2_greenboot.sha256sum] = "243fb8f8932347d6e2f28e60e22112b45e3fa218c601d2062e1d1f462c9ca3a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/greenboot-default-health-checks-0.16.4-0.el10.x86_64_v2.rpm;name=x86_64_v2_greenboot-default-health-checks;unpack=0"
SRC_URI[x86_64_v2_greenboot-default-health-checks.sha256sum] = "d1c89ad192cfbb56fc98c3a43228f0220fd6f803f07f9ca8427701b8fa97a579"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/greenboot-0.16.4-0.el10.aarch64.rpm;name=aarch64_greenboot;unpack=0"
SRC_URI[aarch64_greenboot.sha256sum] = "af753388c1ba9f0315771085d43bc2b6ebcaf66fea5d685e5f472f20fbbcfe6f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/greenboot-default-health-checks-0.16.4-0.el10.aarch64.rpm;name=aarch64_greenboot-default-health-checks;unpack=0"
SRC_URI[aarch64_greenboot-default-health-checks.sha256sum] = "fb32969477db2b98384e74ac7e6544df6d03c455f3843d074625f6b28408b766"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/greenboot-0.16.4-0.el10.riscv64.rpm;name=riscv64_greenboot;unpack=0"
SRC_URI[riscv64_greenboot.sha256sum] = "81249eda8e56f0447c2b7dc2cc88f2fb9145bea7203abec8267c9ece29f45dc1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/greenboot-default-health-checks-0.16.4-0.el10.riscv64.rpm;name=riscv64_greenboot-default-health-checks;unpack=0"
SRC_URI[riscv64_greenboot-default-health-checks.sha256sum] = "04757dd32ae762189e033e7c7bad848399de960145b6ce18b24c556626793c48"

RDEPENDS:greenboot = " \
 bash \
 glibc \
 libgcc \
 pam \
 rpm-ostree \
 systemd \
 "
RDEPENDS:greenboot-default-health-checks = " \
 bash \
 greenboot \
 jq \
 util-linux \
 "
