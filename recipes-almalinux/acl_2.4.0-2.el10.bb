# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "acl"
PV = "2.4.0"
PR = "2.el10"
PACKAGES = " \
 acl \
 libacl \
 libacl-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/acl-2.4.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cfb7bcfb99680e3e7c97f80f9cab05f2b6005c457915ee90deda2616fc7968e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/acl-2.4.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_acl;unpack=0"
SRC_URI[x86_64_v2_acl.sha256sum] = "8fad6443bfab384c8e353af1818c0d6708c3947948dcf6e3cb7ed733f0e0007a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libacl-2.4.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libacl;unpack=0"
SRC_URI[x86_64_v2_libacl.sha256sum] = "da486f671ecc95885780117de1bba316493de560c01f958c3010702ae91b62af"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libacl-devel-2.4.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libacl-devel;unpack=0"
SRC_URI[x86_64_v2_libacl-devel.sha256sum] = "d815f25680e9511b40fcef04ee21eb89bc0483875ed3c42d511ab759a7c6c259"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/acl-2.4.0-2.el10.aarch64.rpm;name=aarch64_acl;unpack=0"
SRC_URI[aarch64_acl.sha256sum] = "f27712974ec04d0244a01ce88be6518111142d7ec078e9238a9116c91efd76d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libacl-2.4.0-2.el10.aarch64.rpm;name=aarch64_libacl;unpack=0"
SRC_URI[aarch64_libacl.sha256sum] = "f6a191c39bb634a059a8849a3a6b44a79e278b371c8255aa747ad994833a91de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libacl-devel-2.4.0-2.el10.aarch64.rpm;name=aarch64_libacl-devel;unpack=0"
SRC_URI[aarch64_libacl-devel.sha256sum] = "d7814f384ae630beef75bd96c80144028891f937f3e6c3463427d3aa34a88011"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/acl-2.4.0-2.el10.riscv64.rpm;name=riscv64_acl;unpack=0"
SRC_URI[riscv64_acl.sha256sum] = "f8b0146b9c4cf62b5aad774ea3dd98124862bf2f3a38dcd7eed0b092c5fed522"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libacl-2.4.0-2.el10.riscv64.rpm;name=riscv64_libacl;unpack=0"
SRC_URI[riscv64_libacl.sha256sum] = "db1fc94f6be4ec2cb9da45e20049f581e7f83f3492caae6789d5aa9b1cf4f991"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libacl-devel-2.4.0-2.el10.riscv64.rpm;name=riscv64_libacl-devel;unpack=0"
SRC_URI[riscv64_libacl-devel.sha256sum] = "50b39b47604ad84e42cd77004e8b6dcf7c7372a706b2e5a70560301cb433e35b"

RDEPENDS:acl = " \
 glibc \
 libacl \
 "
RDEPENDS:libacl = " \
 glibc \
 "
RDEPENDS:libacl-devel = " \
 libacl \
 libattr-devel \
 pkgconf-pkg-config \
 "
