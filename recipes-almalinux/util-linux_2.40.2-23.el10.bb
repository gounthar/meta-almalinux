# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "util-linux"
PV = "2.40.2"
PR = "23.el10"
PACKAGES = " \
 libblkid \
 libblkid-devel \
 libfdisk \
 libfdisk-devel \
 libmount \
 libmount-devel \
 libsmartcols \
 libsmartcols-devel \
 libuuid \
 libuuid-devel \
 python3-libmount \
 util-linux \
 util-linux-core \
 uuidd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/util-linux-2.40.2-23.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4ac83f35b71979b395cae434ce5a966379c7612974b15c4b1c5f511f4a75e51d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libblkid-2.40.2-23.el10.x86_64_v2.rpm;name=x86_64_v2_libblkid;unpack=0"
SRC_URI[x86_64_v2_libblkid.sha256sum] = "26f11f8051ccd5ef97d3b835b9f855623c943856f013a15772650deb1d581699"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblkid-devel-2.40.2-23.el10.x86_64_v2.rpm;name=x86_64_v2_libblkid-devel;unpack=0"
SRC_URI[x86_64_v2_libblkid-devel.sha256sum] = "bfca4482cfb4922cfe4e3fcd10e36b0a596d501e9320474a61ac740f9434e3a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libfdisk-2.40.2-23.el10.x86_64_v2.rpm;name=x86_64_v2_libfdisk;unpack=0"
SRC_URI[x86_64_v2_libfdisk.sha256sum] = "7893e88a45c1164158fb2fc402078fcb36e1c7a45c0a9893d56f430c4fdee3f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libfdisk-devel-2.40.2-23.el10.x86_64_v2.rpm;name=x86_64_v2_libfdisk-devel;unpack=0"
SRC_URI[x86_64_v2_libfdisk-devel.sha256sum] = "af60aea1ebc236afb330a7acf6dea2804b45610f7feeaa214cb4f42b686e7eaf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libmount-2.40.2-23.el10.x86_64_v2.rpm;name=x86_64_v2_libmount;unpack=0"
SRC_URI[x86_64_v2_libmount.sha256sum] = "05c2c386aeb3389733573910a721c2168340988e826fd6f7eb249329ed6a41ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libmount-devel-2.40.2-23.el10.x86_64_v2.rpm;name=x86_64_v2_libmount-devel;unpack=0"
SRC_URI[x86_64_v2_libmount-devel.sha256sum] = "1fcf54505da3648078547456c41fddc899f7b8d48462451806fff9343bf73b55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsmartcols-2.40.2-23.el10.x86_64_v2.rpm;name=x86_64_v2_libsmartcols;unpack=0"
SRC_URI[x86_64_v2_libsmartcols.sha256sum] = "c9fb343b573562606a0cd14258fe68185e092e8bffe2251d94b9d393b3a748f5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsmartcols-devel-2.40.2-23.el10.x86_64_v2.rpm;name=x86_64_v2_libsmartcols-devel;unpack=0"
SRC_URI[x86_64_v2_libsmartcols-devel.sha256sum] = "36a9d92050cb52d91593f62ebaea4edefd8d211829f6812d9db5e24365018308"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libuuid-2.40.2-23.el10.x86_64_v2.rpm;name=x86_64_v2_libuuid;unpack=0"
SRC_URI[x86_64_v2_libuuid.sha256sum] = "1ba428c4a63c312204c7e65337f64f95aabe3b8011e4f728877cfb9205c05fdb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libuuid-devel-2.40.2-23.el10.x86_64_v2.rpm;name=x86_64_v2_libuuid-devel;unpack=0"
SRC_URI[x86_64_v2_libuuid-devel.sha256sum] = "f1a977b26462008b1d8cb4496f5aa0c7435774db34d757c014567b5b84ce1f01"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libmount-2.40.2-23.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libmount;unpack=0"
SRC_URI[x86_64_v2_python3-libmount.sha256sum] = "6d66cbbcad427e97f14ca73bbae3ad768e72d8c3677009bdd55670fe6d2a49f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/util-linux-2.40.2-23.el10.x86_64_v2.rpm;name=x86_64_v2_util-linux;unpack=0"
SRC_URI[x86_64_v2_util-linux.sha256sum] = "6cfc840667b901857e22518dde631e4d103a0d9aaf755ed5f02a951a44fa386c"
RPROVIDES:util-linux:append:x86_64_v2 = " virtual/util-linux-core_or_util-linux"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/util-linux-core-2.40.2-23.el10.x86_64_v2.rpm;name=x86_64_v2_util-linux-core;unpack=0"
SRC_URI[x86_64_v2_util-linux-core.sha256sum] = "db13d3204d10c517cee074192f5f8828eafd53413740d9916f507308381d6643"
RPROVIDES:util-linux-core:append:x86_64_v2 = " virtual/util-linux-core_or_util-linux"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/uuidd-2.40.2-23.el10.x86_64_v2.rpm;name=x86_64_v2_uuidd;unpack=0"
SRC_URI[x86_64_v2_uuidd.sha256sum] = "36b5347172f5274d95ae8e6355f0ae78d08282fa0184abae62b1742d1f2e3f47"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libblkid-2.40.2-23.el10.aarch64.rpm;name=aarch64_libblkid;unpack=0"
SRC_URI[aarch64_libblkid.sha256sum] = "5532299454e66905cacabc80f5694c0b36ad5a073b296c46caaa92480bf65cdc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblkid-devel-2.40.2-23.el10.aarch64.rpm;name=aarch64_libblkid-devel;unpack=0"
SRC_URI[aarch64_libblkid-devel.sha256sum] = "8ea7c11b84ab4b24caa83e211aa2628a9d61551bd8ae1b3a4004f8c1f0efbdc6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libfdisk-2.40.2-23.el10.aarch64.rpm;name=aarch64_libfdisk;unpack=0"
SRC_URI[aarch64_libfdisk.sha256sum] = "30f73bfcd802f2985755518ade5e72d63bc331280aa77619de13b6d8eaa3ac72"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libfdisk-devel-2.40.2-23.el10.aarch64.rpm;name=aarch64_libfdisk-devel;unpack=0"
SRC_URI[aarch64_libfdisk-devel.sha256sum] = "fc54896a7857f624779e33e1a1631d04f03251985928850ee2635309a0b2ce03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libmount-2.40.2-23.el10.aarch64.rpm;name=aarch64_libmount;unpack=0"
SRC_URI[aarch64_libmount.sha256sum] = "9a50329ac2b8e518ec92b19bfb2dd684178d960c991a53f6f339cad8befdb7e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libmount-devel-2.40.2-23.el10.aarch64.rpm;name=aarch64_libmount-devel;unpack=0"
SRC_URI[aarch64_libmount-devel.sha256sum] = "f7338e94651e5f1c9e4c323a5d10ecc0ea235d0a0e5a98386845daa1fc0b01cb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsmartcols-2.40.2-23.el10.aarch64.rpm;name=aarch64_libsmartcols;unpack=0"
SRC_URI[aarch64_libsmartcols.sha256sum] = "3433ddb7bd44f6b793c359b8947aecebdcf934244cd4c05b9d8237d1cfe1e3d6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsmartcols-devel-2.40.2-23.el10.aarch64.rpm;name=aarch64_libsmartcols-devel;unpack=0"
SRC_URI[aarch64_libsmartcols-devel.sha256sum] = "bd706c740dcadd984896aa9ccf230e704bec9f1e2fcb3dcb304cd81b3678b081"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libuuid-2.40.2-23.el10.aarch64.rpm;name=aarch64_libuuid;unpack=0"
SRC_URI[aarch64_libuuid.sha256sum] = "a9aa3900b613a51000ebf602f5a6604aa1a9e8c7931b31a54f4973900d15c6bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libuuid-devel-2.40.2-23.el10.aarch64.rpm;name=aarch64_libuuid-devel;unpack=0"
SRC_URI[aarch64_libuuid-devel.sha256sum] = "eac630866b5a2625cfcb2738e1ef14a955b96d349b1b60cfe28091d26c8d1ecd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libmount-2.40.2-23.el10.aarch64.rpm;name=aarch64_python3-libmount;unpack=0"
SRC_URI[aarch64_python3-libmount.sha256sum] = "834f9fe4bfab80b9bc25a2ccd772301ed746256257314bdeb57cb20b40b87573"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/util-linux-2.40.2-23.el10.aarch64.rpm;name=aarch64_util-linux;unpack=0"
SRC_URI[aarch64_util-linux.sha256sum] = "66ab3c0a2f67bdc664a86052a93416165a0231f1316c34c221a3b0d455fbcac2"
RPROVIDES:util-linux:append:aarch64 = " virtual/util-linux-core_or_util-linux"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/util-linux-core-2.40.2-23.el10.aarch64.rpm;name=aarch64_util-linux-core;unpack=0"
SRC_URI[aarch64_util-linux-core.sha256sum] = "7230f9350500fc13574122b0b34f4a852d261671a20b7c508d1a1e31ee3ae65c"
RPROVIDES:util-linux-core:append:aarch64 = " virtual/util-linux-core_or_util-linux"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/uuidd-2.40.2-23.el10.aarch64.rpm;name=aarch64_uuidd;unpack=0"
SRC_URI[aarch64_uuidd.sha256sum] = "73ac433095045767bd8a8df058272132c255bcd6f9dfefd0fa17f92b2f160e79"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libblkid-2.40.2-23.el10.riscv64.rpm;name=riscv64_libblkid;unpack=0"
SRC_URI[riscv64_libblkid.sha256sum] = "cbb1da6e5029ac85322bc2814c7d37c24d7fd10a4fc00f422bd015b1b563c5f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libblkid-devel-2.40.2-23.el10.riscv64.rpm;name=riscv64_libblkid-devel;unpack=0"
SRC_URI[riscv64_libblkid-devel.sha256sum] = "a4154d53ac4597f04397cda16f33abcf8e838c29a4760ebda2c7518be666fe0c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libfdisk-2.40.2-23.el10.riscv64.rpm;name=riscv64_libfdisk;unpack=0"
SRC_URI[riscv64_libfdisk.sha256sum] = "59082593f916782424702d2661ba1ca05bec0b4afca6784d102e89a0a3adf041"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/libfdisk-devel-2.40.2-23.el10.riscv64.rpm;name=riscv64_libfdisk-devel;unpack=0"
SRC_URI[riscv64_libfdisk-devel.sha256sum] = "731203ad8f669aae965e3c789dbbafed1405de1c1afd68c7139f2116b12e56db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libmount-2.40.2-23.el10.riscv64.rpm;name=riscv64_libmount;unpack=0"
SRC_URI[riscv64_libmount.sha256sum] = "b5646b0bc05c9b7a67a2613d6f698c53bd10173e3f78c3f734c8eb24743aa356"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libmount-devel-2.40.2-23.el10.riscv64.rpm;name=riscv64_libmount-devel;unpack=0"
SRC_URI[riscv64_libmount-devel.sha256sum] = "a2c4e9cd6ec08e2b9af04d649c11b992e0cfd18c0ffe39cc6e498bd7c5853047"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libsmartcols-2.40.2-23.el10.riscv64.rpm;name=riscv64_libsmartcols;unpack=0"
SRC_URI[riscv64_libsmartcols.sha256sum] = "c61e3871a7c58d95c24bc67dffec869231822160e69d2812ffe0c9082e3cb0e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/libsmartcols-devel-2.40.2-23.el10.riscv64.rpm;name=riscv64_libsmartcols-devel;unpack=0"
SRC_URI[riscv64_libsmartcols-devel.sha256sum] = "a283dd6467161259aa3ffb94d8f9fb1fa9da14c1d9e031d7cf0ad3fc09d5644d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libuuid-2.40.2-23.el10.riscv64.rpm;name=riscv64_libuuid;unpack=0"
SRC_URI[riscv64_libuuid.sha256sum] = "33648553bfae5469ed18461f2669165a6c0dd0fc20029ded601d12a580d0c98a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libuuid-devel-2.40.2-23.el10.riscv64.rpm;name=riscv64_libuuid-devel;unpack=0"
SRC_URI[riscv64_libuuid-devel.sha256sum] = "af15cc64ad89779d4d08b19499e4c0d4846d8adb3e95bc9ecc52000d6a23e593"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/python3-libmount-2.40.2-23.el10.riscv64.rpm;name=riscv64_python3-libmount;unpack=0"
SRC_URI[riscv64_python3-libmount.sha256sum] = "e3c12acabd0cb518f24ef555d410cd2da428de11cbdc2396594ba3f09171cf4f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/util-linux-2.40.2-23.el10.riscv64.rpm;name=riscv64_util-linux;unpack=0"
SRC_URI[riscv64_util-linux.sha256sum] = "3c8ca86807499f7d6d63da844ca78575ac2e4f0b77c95d958f2ac98c86b4b458"
RPROVIDES:util-linux:append:riscv64 = " virtual/util-linux-core_or_util-linux"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/util-linux-core-2.40.2-23.el10.riscv64.rpm;name=riscv64_util-linux-core;unpack=0"
SRC_URI[riscv64_util-linux-core.sha256sum] = "302991c2fa28c516dcd46dec70c07950536305ed7f758a5f6c0a33c06d119ede"
RPROVIDES:util-linux-core:append:riscv64 = " virtual/util-linux-core_or_util-linux"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/uuidd-2.40.2-23.el10.riscv64.rpm;name=riscv64_uuidd;unpack=0"
SRC_URI[riscv64_uuidd.sha256sum] = "85848fae474e1b820a7f5db03afc914b3d9de00953669d86fd626648c23c0de8"

RDEPENDS:libblkid = " \
 glibc \
 libuuid \
 "
RDEPENDS:libblkid-devel = " \
 libblkid \
 pkgconf-pkg-config \
 "
RDEPENDS:libfdisk = " \
 glibc \
 libblkid \
 libuuid \
 "
RDEPENDS:libfdisk-devel = " \
 libblkid-devel \
 libfdisk \
 libuuid-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libmount = " \
 glibc \
 libblkid \
 libselinux \
 libuuid \
 "
RDEPENDS:libmount-devel = " \
 libblkid-devel \
 libmount \
 libselinux-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libsmartcols = " \
 glibc \
 "
RDEPENDS:libsmartcols-devel = " \
 libsmartcols \
 pkgconf-pkg-config \
 "
RDEPENDS:libuuid = " \
 glibc \
 "
RDEPENDS:libuuid-devel = " \
 libuuid \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libmount = " \
 glibc \
 libblkid \
 libmount \
 libselinux \
 python3 \
 "
RDEPENDS:util-linux = " \
 audit-libs \
 authselect-libs \
 bash \
 glibc \
 libblkid \
 libcap-ng \
 libfdisk \
 libmount \
 libselinux \
 libsmartcols \
 libutempter \
 libuuid \
 ncurses-libs \
 pam \
 pam-libs \
 readline \
 shadow-utils \
 systemd-libs \
 util-linux-core \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:util-linux-core = " \
 glibc \
 libblkid \
 libmount \
 libselinux \
 libsmartcols \
 libuuid \
 libxcrypt \
 ncurses-libs \
 systemd-libs \
 "
RDEPENDS:uuidd = " \
 bash \
 glibc \
 libuuid \
 shadow-utils \
 systemd-libs \
 "
