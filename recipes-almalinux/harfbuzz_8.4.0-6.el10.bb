# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "harfbuzz"
PV = "8.4.0"
PR = "6.el10"
PACKAGES = " \
 harfbuzz \
 harfbuzz-cairo \
 harfbuzz-devel \
 harfbuzz-icu \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/harfbuzz-8.4.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4d8596aad6cf9a09d0f77c13f4909e8deaccf822a98187a366682d1544705da8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/harfbuzz-8.4.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_harfbuzz;unpack=0"
SRC_URI[x86_64_v2_harfbuzz.sha256sum] = "587b44404de519c23a390c5b92b949df490d1c0d16864a3ee550a31ae5023041"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/harfbuzz-cairo-8.4.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_harfbuzz-cairo;unpack=0"
SRC_URI[x86_64_v2_harfbuzz-cairo.sha256sum] = "409f6deae01f43ac842dfe0286a44b1b0fe778579acd2e62efb18cd2d57e4cad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/harfbuzz-devel-8.4.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_harfbuzz-devel;unpack=0"
SRC_URI[x86_64_v2_harfbuzz-devel.sha256sum] = "a15b3d5ea977929219e9d693716a7622578534fd6a0993177910c6868cdbd0a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/harfbuzz-icu-8.4.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_harfbuzz-icu;unpack=0"
SRC_URI[x86_64_v2_harfbuzz-icu.sha256sum] = "b0cca69752e15a5fe63ea03598fbfa8a77e0911857405971089a09c30426b353"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/harfbuzz-8.4.0-6.el10.aarch64.rpm;name=aarch64_harfbuzz;unpack=0"
SRC_URI[aarch64_harfbuzz.sha256sum] = "25db5632bda3fa610400142f0d424674f6ace45370a2e0b235f048b57a621aaa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/harfbuzz-cairo-8.4.0-6.el10.aarch64.rpm;name=aarch64_harfbuzz-cairo;unpack=0"
SRC_URI[aarch64_harfbuzz-cairo.sha256sum] = "7061d2cd432595b15822734a05b2e6b3589b32af9ef726d4c6747ab64d51379b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/harfbuzz-devel-8.4.0-6.el10.aarch64.rpm;name=aarch64_harfbuzz-devel;unpack=0"
SRC_URI[aarch64_harfbuzz-devel.sha256sum] = "70aabdec8354b7c24e080ad0da4102385bfffca0694cd7ec476de398dbf5ddb3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/harfbuzz-icu-8.4.0-6.el10.aarch64.rpm;name=aarch64_harfbuzz-icu;unpack=0"
SRC_URI[aarch64_harfbuzz-icu.sha256sum] = "cdfa2a535934cc60b0f269edeed39377e901a4233641e113beb65406b50c0137"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/harfbuzz-8.4.0-6.el10.riscv64.rpm;name=riscv64_harfbuzz;unpack=0"
SRC_URI[riscv64_harfbuzz.sha256sum] = "ce2f62a4fba66d747e15e5c07068b9d775d31670a35db3b180451da29d99840c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/harfbuzz-cairo-8.4.0-6.el10.riscv64.rpm;name=riscv64_harfbuzz-cairo;unpack=0"
SRC_URI[riscv64_harfbuzz-cairo.sha256sum] = "e5357bffbe042eac6d2c3fa5b91cd317507f442fe231309e66afae2a3c2a9785"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/harfbuzz-devel-8.4.0-6.el10.riscv64.rpm;name=riscv64_harfbuzz-devel;unpack=0"
SRC_URI[riscv64_harfbuzz-devel.sha256sum] = "f21a57660cb31724e9546854b0658e42df5ea8597c78e4b88e40cd8b6bc52793"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/harfbuzz-icu-8.4.0-6.el10.riscv64.rpm;name=riscv64_harfbuzz-icu;unpack=0"
SRC_URI[riscv64_harfbuzz-icu.sha256sum] = "dbf7fc70df675ebb391ab1860701e136b28dbe63f9aa2b23f97bfa3cccbcfbfd"

RDEPENDS:harfbuzz = " \
 freetype \
 glib2 \
 glibc \
 graphite2 \
 "
RDEPENDS:harfbuzz-cairo = " \
 cairo \
 glibc \
 harfbuzz \
 "
RDEPENDS:harfbuzz-devel = " \
 cairo \
 cairo-devel \
 freetype \
 freetype-devel \
 glib2 \
 glib2-devel \
 glibc \
 graphite2-devel \
 harfbuzz \
 harfbuzz-cairo \
 harfbuzz-icu \
 libicu-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:harfbuzz-icu = " \
 glibc \
 harfbuzz \
 libicu \
 "
