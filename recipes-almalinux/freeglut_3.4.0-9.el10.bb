# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freeglut"
PV = "3.4.0"
PR = "9.el10"
PACKAGES = " \
 freeglut \
 freeglut-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/freeglut-3.4.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0e438f7e62e71c86e2e96851ff503dcc00b35d2c671790e8df1e3ccf9304acdd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeglut-3.4.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_freeglut;unpack=0"
SRC_URI[x86_64_v2_freeglut.sha256sum] = "6d67f9e203d1324a977e52787606a69622e2e782bf0daec94ff08df106749925"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeglut-devel-3.4.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_freeglut-devel;unpack=0"
SRC_URI[x86_64_v2_freeglut-devel.sha256sum] = "a7626e5b3bb390de4c40c2d4f03a7955adf63068165c88f061021a647a6d6d3c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeglut-3.4.0-9.el10.aarch64.rpm;name=aarch64_freeglut;unpack=0"
SRC_URI[aarch64_freeglut.sha256sum] = "c169a31ac6d7e64887e609c6cc7432e1fc63bf3f764ab9ffcad7ffa7497aa5f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeglut-devel-3.4.0-9.el10.aarch64.rpm;name=aarch64_freeglut-devel;unpack=0"
SRC_URI[aarch64_freeglut-devel.sha256sum] = "666ddcc79495f46d0da30217b4ff48cf0289e5a721d3f0862927fcd7ac06c311"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/freeglut-3.4.0-9.el10.riscv64.rpm;name=riscv64_freeglut;unpack=0"
SRC_URI[riscv64_freeglut.sha256sum] = "2bc0793e37729338c52354bfeb8614ed52c343b174551cb2aaadb1a4c8a2fb95"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/freeglut-devel-3.4.0-9.el10.riscv64.rpm;name=riscv64_freeglut-devel;unpack=0"
SRC_URI[riscv64_freeglut-devel.sha256sum] = "a8fcc6095ca63d811b7111ee7d1d25edb7657c6d7bf6d3a080451e4b80b0dec9"

RDEPENDS:freeglut = " \
 glibc \
 libX11 \
 libXi \
 libglvnd-glx \
 "
RDEPENDS:freeglut-devel = " \
 cmake-filesystem \
 freeglut \
 mesa-libGL-devel \
 mesa-libGLU-devel \
 pkgconf-pkg-config \
 "
