# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "criu"
PV = "4.2"
PR = "9.el10.alma.1"
PACKAGES = " \
 crit \
 criu \
 criu-devel \
 criu-libs \
 python3-criu \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/criu-4.2-9.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cf64bcff0d8d6ba10a45293a53b54d22320bbde7796562482726a077dcbe8c00"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crit-4.2-9.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_crit;unpack=0"
SRC_URI[x86_64_v2_crit.sha256sum] = "0d9c72d28fd9988ece3ed6fc0befbf179dbff2f2ce2a8e6a7c3706abc989c1cb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/criu-4.2-9.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_criu;unpack=0"
SRC_URI[x86_64_v2_criu.sha256sum] = "f2f61450e0f86d59ac6f0264b1a912aa59713af4981225154c99dc93676f1ccc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/criu-devel-4.2-9.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_criu-devel;unpack=0"
SRC_URI[x86_64_v2_criu-devel.sha256sum] = "6f4f21efb57af796b7b31067d311d2dfc105f74a7c52fd65ebdbe67d7e71654d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/criu-libs-4.2-9.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_criu-libs;unpack=0"
SRC_URI[x86_64_v2_criu-libs.sha256sum] = "d267fc49d5211d250a8f57b5ed0ab673416bdfff415d5f730666e6830c5be5cf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-criu-4.2-9.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-criu;unpack=0"
SRC_URI[x86_64_v2_python3-criu.sha256sum] = "7a71ee1869e755c413eb1d6b0381eea73798dd1508b142aa14350b7c6869f925"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crit-4.2-9.el10.alma.1.aarch64.rpm;name=aarch64_crit;unpack=0"
SRC_URI[aarch64_crit.sha256sum] = "325465a55d1b53fbdebd48959654c3befa653c719ba8559f19a989cf21e0edaf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/criu-4.2-9.el10.alma.1.aarch64.rpm;name=aarch64_criu;unpack=0"
SRC_URI[aarch64_criu.sha256sum] = "563ffbb45c2458ea593004a204d9369a0285e2a36add429af04b82117d29f571"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/criu-devel-4.2-9.el10.alma.1.aarch64.rpm;name=aarch64_criu-devel;unpack=0"
SRC_URI[aarch64_criu-devel.sha256sum] = "3b1bb9c593a1ed8ae3bdca39c4ec1b0a7554f32bc544c53cb8d935cc84efb637"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/criu-libs-4.2-9.el10.alma.1.aarch64.rpm;name=aarch64_criu-libs;unpack=0"
SRC_URI[aarch64_criu-libs.sha256sum] = "eb3cb6892560a1daaab34f7b3bce04773f1b98ba5adf2f37a35bf454aaf11497"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-criu-4.2-9.el10.alma.1.aarch64.rpm;name=aarch64_python3-criu;unpack=0"
SRC_URI[aarch64_python3-criu.sha256sum] = "1894b4f84f369bdad91787c7bdcc95d8797ea15afad29978fb034a2eb27e09c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/crit-4.2-9.el10.alma.1.riscv64.rpm;name=riscv64_crit;unpack=0"
SRC_URI[riscv64_crit.sha256sum] = "8181928b42c05c41796c4956cbb9f35ccd255d57af40b2ed4fa2d2a64cb55b29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/criu-4.2-9.el10.alma.1.riscv64.rpm;name=riscv64_criu;unpack=0"
SRC_URI[riscv64_criu.sha256sum] = "f89bb76b07b12586bc845a90ffa50a1f0295c66a062ba8919ccb47dffab6d599"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/criu-devel-4.2-9.el10.alma.1.riscv64.rpm;name=riscv64_criu-devel;unpack=0"
SRC_URI[riscv64_criu-devel.sha256sum] = "02c373e11665e324489757c62231d87095dc37c38cb89b37c5b1cf4349c3647c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/criu-libs-4.2-9.el10.alma.1.riscv64.rpm;name=riscv64_criu-libs;unpack=0"
SRC_URI[riscv64_criu-libs.sha256sum] = "da2d2efcd164a8f0fd0a402f7dd5419561eb014bef7c08ae0e2e4a255bdeda52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/python3-criu-4.2-9.el10.alma.1.riscv64.rpm;name=riscv64_python3-criu;unpack=0"
SRC_URI[riscv64_python3-criu.sha256sum] = "e2aa3fcf7c4b6b3a9f7928a12bbd0993dbe89d8c14e15d8623231ea021d2e6f8"

RDEPENDS:crit = " \
 python3 \
 python3-criu \
 "
RDEPENDS:criu = " \
 bash \
 glibc \
 gnutls \
 libgcc \
 libnet \
 libnl3 \
 libselinux \
 libuuid \
 nftables \
 protobuf-c \
 "
RDEPENDS:criu-devel = " \
 criu \
 criu-libs \
 pkgconf-pkg-config \
 protobuf-c-devel \
 "
RDEPENDS:criu-libs = " \
 criu \
 glibc \
 protobuf-c \
 "
RDEPENDS:python3-criu = " \
 python3 \
 python3-protobuf \
 "
