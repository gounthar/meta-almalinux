# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdvdread"
PV = "6.1.3"
PR = "9.el10"
PACKAGES = " \
 libdvdread \
 libdvdread-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libdvdread-6.1.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9e40d16c45f1c53ba9d241f869f12b30465f6f636341a1d46a83fb0016439324"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libdvdread-6.1.3-9.el10.x86_64_v2.rpm;name=x86_64_v2_libdvdread;unpack=0"
SRC_URI[x86_64_v2_libdvdread.sha256sum] = "64b1da9ae281dfe530d46ff5564095567ace386fe63c4b525676f1d5e6b16689"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdvdread-devel-6.1.3-9.el10.x86_64_v2.rpm;name=x86_64_v2_libdvdread-devel;unpack=0"
SRC_URI[x86_64_v2_libdvdread-devel.sha256sum] = "c2d0775803dd1baf090bdf24a98fc8bb5f872871462ca7142789af8060e3290b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libdvdread-6.1.3-9.el10.aarch64.rpm;name=aarch64_libdvdread;unpack=0"
SRC_URI[aarch64_libdvdread.sha256sum] = "aaae1c36546be1a895cf069bba6a46f3c888c146b699b79dd76cc7469cc6f61e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdvdread-devel-6.1.3-9.el10.aarch64.rpm;name=aarch64_libdvdread-devel;unpack=0"
SRC_URI[aarch64_libdvdread-devel.sha256sum] = "f2387c03cab0038fb9095cc28dc96bf374b201b4994819faff06f907e1646199"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libdvdread-6.1.3-9.el10.riscv64.rpm;name=riscv64_libdvdread;unpack=0"
SRC_URI[riscv64_libdvdread.sha256sum] = "61ecb2dffad851afb210decdb67a911474e8eb916ef1deadd9ad8e32b5f4b9d5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/libdvdread-devel-6.1.3-9.el10.riscv64.rpm;name=riscv64_libdvdread-devel;unpack=0"
SRC_URI[riscv64_libdvdread-devel.sha256sum] = "09e2c1109a245d0be1df227a03df95148de704d32d3c56d27332fdd9184c7d61"

RDEPENDS:libdvdread = " \
 glibc \
 "
RDEPENDS:libdvdread-devel = " \
 libdvdread \
 pkgconf-pkg-config \
 "
