# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setools"
PV = "4.7.1"
PR = "1.1.el10"
PACKAGES = " \
 python3-setools \
 setools \
 setools-console \
 setools-console-analyses \
 setools-gui \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/setools-4.7.1-1.1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "25ddea0ffa4a314fec6c6b98465d8f9b8016090c2bbd32383bf44a818a1b2b16"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-setools-4.7.1-1.1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-setools;unpack=0"
SRC_URI[x86_64_v2_python3-setools.sha256sum] = "2ca32f4da714ec61958f4faee19136cae028ace5001b80737851bafa33a0665a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-4.7.1-1.1.el10.x86_64_v2.rpm;name=x86_64_v2_setools;unpack=0"
SRC_URI[x86_64_v2_setools.sha256sum] = "ffa145253c47f20608a973d1511b938cbe1f686d643ecea6a3c299be4d2d1a10"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/setools-console-4.7.1-1.1.el10.x86_64_v2.rpm;name=x86_64_v2_setools-console;unpack=0"
SRC_URI[x86_64_v2_setools-console.sha256sum] = "9e6291394332f8705a70ad7da87d2d254648bdbcc4c03e619e81e4df4dddbab3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-console-analyses-4.7.1-1.1.el10.x86_64_v2.rpm;name=x86_64_v2_setools-console-analyses;unpack=0"
SRC_URI[x86_64_v2_setools-console-analyses.sha256sum] = "55ca24e4b67f6bc5256262f105b83313c16caaeffaa09db077a15189f7501e28"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-gui-4.7.1-1.1.el10.x86_64_v2.rpm;name=x86_64_v2_setools-gui;unpack=0"
SRC_URI[x86_64_v2_setools-gui.sha256sum] = "24e1465a8e67f3c71c6e56fe7aa31ed10883b52a6bb36f10bc4bc799ac714744"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-setools-4.7.1-1.1.el10.aarch64.rpm;name=aarch64_python3-setools;unpack=0"
SRC_URI[aarch64_python3-setools.sha256sum] = "d877c3f7bd2057fe3b538b390c41bbccc6cb304b4c6bd523056949b5eab20a4f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-4.7.1-1.1.el10.aarch64.rpm;name=aarch64_setools;unpack=0"
SRC_URI[aarch64_setools.sha256sum] = "f8d7a8f93d8f9f7eff35b952cc2b6e102cd209271fad489d3d21536da8f74efd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/setools-console-4.7.1-1.1.el10.aarch64.rpm;name=aarch64_setools-console;unpack=0"
SRC_URI[aarch64_setools-console.sha256sum] = "336a0dad8a3fe72d26e8fe8d0482707157f7e88ab26eec5658f5c2ab241d97a9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-console-analyses-4.7.1-1.1.el10.aarch64.rpm;name=aarch64_setools-console-analyses;unpack=0"
SRC_URI[aarch64_setools-console-analyses.sha256sum] = "ff3dd44488071949dc29dea52fe489d6ce7a55f9e8c888aec2c977e6d909de5d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-gui-4.7.1-1.1.el10.aarch64.rpm;name=aarch64_setools-gui;unpack=0"
SRC_URI[aarch64_setools-gui.sha256sum] = "a5f08c469e14f5631463f1e296b9a1e8b18438b6b071741c970d2464c7b5d547"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/python3-setools-4.7.1-1.1.el10.riscv64.rpm;name=riscv64_python3-setools;unpack=0"
SRC_URI[riscv64_python3-setools.sha256sum] = "0e83c0b1dd7430b25b3267e6b88b670a22bf2bd95a4ed44f01cd3c8de208e26b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/setools-4.7.1-1.1.el10.riscv64.rpm;name=riscv64_setools;unpack=0"
SRC_URI[riscv64_setools.sha256sum] = "7067445502c57f2f94fab621d29fa28dfe43dee83a73722e6ef75b344280babf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/setools-console-4.7.1-1.1.el10.riscv64.rpm;name=riscv64_setools-console;unpack=0"
SRC_URI[riscv64_setools-console.sha256sum] = "041d937e5e574a161f9040dd99f023eb300250d127d2d5e09bfc86f56fb1f88b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/setools-console-analyses-4.7.1-1.1.el10.riscv64.rpm;name=riscv64_setools-console-analyses;unpack=0"
SRC_URI[riscv64_setools-console-analyses.sha256sum] = "c9ade3dec06e6c62045ff36df0b702dd48d90247bc51191706ea93b90171089d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/setools-gui-4.7.1-1.1.el10.riscv64.rpm;name=riscv64_setools-gui;unpack=0"
SRC_URI[riscv64_setools-gui.sha256sum] = "b4179463fb8211372f859f572fcd65ae94c79c994578e5758c7d9a7660bf1ad2"

RDEPENDS:python3-setools = " \
 glibc \
 libselinux \
 libsepol \
 python3 \
 "
RDEPENDS:setools = " \
 setools-console \
 setools-console-analyses \
 setools-gui \
 "
RDEPENDS:setools-console = " \
 libselinux \
 python3 \
 python3-setools \
 "
RDEPENDS:setools-console-analyses = " \
 libselinux \
 python3 \
 python3-networkx \
 python3-setools \
 "
RDEPENDS:setools-gui = " \
 python3 \
 python3-networkx \
 python3-pyqt6 \
 python3-pyqt6-sip \
 python3-setools \
 "
