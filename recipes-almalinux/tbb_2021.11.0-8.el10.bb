# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tbb"
PV = "2021.11.0"
PR = "8.el10"
PACKAGES = " \
 python3-tbb \
 tbb \
 tbb-bind \
 tbb-devel \
 tbb-doc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tbb-2021.11.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "239e88dc7226b02dcda8208e99e390e859274b81df2fd34c2e74ee9d5be36479"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tbb-2021.11.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_python3-tbb;unpack=0"
SRC_URI[x86_64_v2_python3-tbb.sha256sum] = "423ae646384b13cd9814ccaecc4c4e82cc19e333e44653eb766d07a6203de0ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tbb-2021.11.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_tbb;unpack=0"
SRC_URI[x86_64_v2_tbb.sha256sum] = "9339d3e8ef2b8f797e605bbd91c999d1d568ad97f313b75f181985bd16b5d6e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tbb-bind-2021.11.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_tbb-bind;unpack=0"
SRC_URI[x86_64_v2_tbb-bind.sha256sum] = "db27177990b8726843d090346bd297b02bb3e06f06721c16c0e663c0618540e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tbb-devel-2021.11.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_tbb-devel;unpack=0"
SRC_URI[x86_64_v2_tbb-devel.sha256sum] = "17a3eb4c0865dada9f0037fbda36673928fcf7f1524662aee620942cf77fbec6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tbb-doc-2021.11.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_tbb-doc;unpack=0"
SRC_URI[x86_64_v2_tbb-doc.sha256sum] = "5f8230545aba251c56b8a9247585b088ce3be6dbc8dee6a65653933c0f7f67c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tbb-2021.11.0-8.el10.aarch64.rpm;name=aarch64_python3-tbb;unpack=0"
SRC_URI[aarch64_python3-tbb.sha256sum] = "89f8f0b50ba0fd20fd876238be1c13f529ddf2551d697d49358f4307e050cab0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tbb-2021.11.0-8.el10.aarch64.rpm;name=aarch64_tbb;unpack=0"
SRC_URI[aarch64_tbb.sha256sum] = "9c13658e8f17a2a3fd276787979e089191dc5222292e9e38ca93359d0afd6eac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tbb-bind-2021.11.0-8.el10.aarch64.rpm;name=aarch64_tbb-bind;unpack=0"
SRC_URI[aarch64_tbb-bind.sha256sum] = "cc852d8c698a79243bbf4cc54288a7dcbe4094b49bf854459a3fe48f3a45896d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tbb-devel-2021.11.0-8.el10.aarch64.rpm;name=aarch64_tbb-devel;unpack=0"
SRC_URI[aarch64_tbb-devel.sha256sum] = "d0666f50ea22524ff46658a9b62f3da316056041ad60515569f82ede68d56f85"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tbb-doc-2021.11.0-8.el10.aarch64.rpm;name=aarch64_tbb-doc;unpack=0"
SRC_URI[aarch64_tbb-doc.sha256sum] = "dfdadd987f474d5ff9aa5f45132ed3b428f71ac9c3401cdd78d106cd98d9657d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/python3-tbb-2021.11.0-8.el10.riscv64.rpm;name=riscv64_python3-tbb;unpack=0"
SRC_URI[riscv64_python3-tbb.sha256sum] = "d233a7294e48955d2bc32d793a7566059276ab0e690c23af010fc4ec6db01a9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/tbb-2021.11.0-8.el10.riscv64.rpm;name=riscv64_tbb;unpack=0"
SRC_URI[riscv64_tbb.sha256sum] = "92aa07b73f94d13a02e2c0d57dbfee749fa76ce7d490436d3e67775d832bb145"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/tbb-bind-2021.11.0-8.el10.riscv64.rpm;name=riscv64_tbb-bind;unpack=0"
SRC_URI[riscv64_tbb-bind.sha256sum] = "162cc9a4c306602a68fb571e2fb5f646b384846bc78fc183fc06758fafa92e0a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/tbb-devel-2021.11.0-8.el10.riscv64.rpm;name=riscv64_tbb-devel;unpack=0"
SRC_URI[riscv64_tbb-devel.sha256sum] = "464344355b1484e6bce19314f0905d831863b9094c5dee299b618ab70102b8c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/tbb-doc-2021.11.0-8.el10.riscv64.rpm;name=riscv64_tbb-doc;unpack=0"
SRC_URI[riscv64_tbb-doc.sha256sum] = "d9dbcbbd5b1f0af783bc54e7f0d153f6d06d359488aaa99db7d096f06702008d"

RDEPENDS:python3-tbb = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 tbb \
 "
RDEPENDS:tbb = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:tbb-bind = " \
 glibc \
 hwloc-libs \
 libgcc \
 libstdc++ \
 tbb \
 "
RDEPENDS:tbb-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 tbb \
 tbb-bind \
 "
RDEPENDS:tbb-doc = " \
 "
