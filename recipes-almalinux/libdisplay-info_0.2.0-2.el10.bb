# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdisplay-info"
PV = "0.2.0"
PR = "2.el10"
PACKAGES = " \
 libdisplay-info \
 libdisplay-info-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libdisplay-info-0.2.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b55fc0645ccea6a774e0b24c291fc63c2036bac895e3c963d665e3f6da4045d5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libdisplay-info-0.2.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libdisplay-info;unpack=0"
SRC_URI[x86_64_v2_libdisplay-info.sha256sum] = "48ef394039932d360cba9f5dd1a396fa3ff04ba58254434953cf3a43d2c11003"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdisplay-info-devel-0.2.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libdisplay-info-devel;unpack=0"
SRC_URI[x86_64_v2_libdisplay-info-devel.sha256sum] = "63168dc56c5f7f5b44ec7ebbcf3faddce19129497d3e1e7a45b220c97894b76b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libdisplay-info-0.2.0-2.el10.aarch64.rpm;name=aarch64_libdisplay-info;unpack=0"
SRC_URI[aarch64_libdisplay-info.sha256sum] = "16a7cf900e2b5f658721176f6cadc46f71ce108ed645f942b8b755844c9ccd03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdisplay-info-devel-0.2.0-2.el10.aarch64.rpm;name=aarch64_libdisplay-info-devel;unpack=0"
SRC_URI[aarch64_libdisplay-info-devel.sha256sum] = "447fa98180e5058b1c3f1ee62c6f58aac6ff43caba1bb7e1e2bb413f00c77ead"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libdisplay-info-0.2.0-2.el10.riscv64.rpm;name=riscv64_libdisplay-info;unpack=0"
SRC_URI[riscv64_libdisplay-info.sha256sum] = "3f0a6fa82d78497457c565086515644c2b61cccc054a47ad90981afaffaed2ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/libdisplay-info-devel-0.2.0-2.el10.riscv64.rpm;name=riscv64_libdisplay-info-devel;unpack=0"
SRC_URI[riscv64_libdisplay-info-devel.sha256sum] = "e8bc570eec7c1a66ae73cf83018550b5e96c89021af7fabba7dade3e4720311a"

RDEPENDS:libdisplay-info = " \
 glibc \
 "
RDEPENDS:libdisplay-info-devel = " \
 libdisplay-info \
 pkgconf-pkg-config \
 "
