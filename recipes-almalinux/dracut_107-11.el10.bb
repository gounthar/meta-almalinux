# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dracut"
PV = "107"
PR = "11.el10"
PACKAGES = " \
 dracut \
 dracut-caps \
 dracut-config-generic \
 dracut-config-rescue \
 dracut-live \
 dracut-network \
 dracut-squash \
 dracut-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dracut-107-11.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "491ab6dd16d5a96e79dea55e8f51f411e1eee415df9b269a1204883950bc608a"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - dracut-caps: libcap

## Requires (riscv64) that were seen as not satisfiable in original repo:
# - dracut-caps: libcap

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-107-11.el10.x86_64_v2.rpm;name=x86_64_v2_dracut;unpack=0"
SRC_URI[x86_64_v2_dracut.sha256sum] = "ca246fdaa5ab12526ba92e15d281dbba1737a3a16a5b916a7b8f4f5a0d52a9fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dracut-caps-107-11.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-caps;unpack=0"
SRC_URI[x86_64_v2_dracut-caps.sha256sum] = "54b2e4ebeb9612d8eb70b02517ed6980195b3d6b5e32ee6b1760ac88e5a374a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-config-generic-107-11.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-config-generic;unpack=0"
SRC_URI[x86_64_v2_dracut-config-generic.sha256sum] = "118f466ab7820b6ac716370691368e04d9055fc65a3a6877c8312bf754b36a40"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-config-rescue-107-11.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-config-rescue;unpack=0"
SRC_URI[x86_64_v2_dracut-config-rescue.sha256sum] = "f6afeb630ccee91e86a6fe9dc8602b64894106e2ccdd1d2e1205aea57834ea98"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dracut-live-107-11.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-live;unpack=0"
SRC_URI[x86_64_v2_dracut-live.sha256sum] = "62d964dc5ae75bfcf8604f1cec50a28b8465f747abbeba3bf7af75aef34a127b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-network-107-11.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-network;unpack=0"
SRC_URI[x86_64_v2_dracut-network.sha256sum] = "e80b0010c2fc75af1cfc665840c8827338f3e62471e4ffc0d4ec7c5f4aecccbb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-squash-107-11.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-squash;unpack=0"
SRC_URI[x86_64_v2_dracut-squash.sha256sum] = "5ad0b58adb10e84c83cbb4c10b9ef37a8864526cb1f23dd5bf5d21e4c32aa870"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-tools-107-11.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-tools;unpack=0"
SRC_URI[x86_64_v2_dracut-tools.sha256sum] = "71954a647254559d341ce8c0ceceb866d329ad41992956b8c0cc54a30483240a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-107-11.el10.aarch64.rpm;name=aarch64_dracut;unpack=0"
SRC_URI[aarch64_dracut.sha256sum] = "1f0afa186058c582cf460157f4615f2048b2b2fe7026d7b16164c107e5cd42bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dracut-caps-107-11.el10.aarch64.rpm;name=aarch64_dracut-caps;unpack=0"
SRC_URI[aarch64_dracut-caps.sha256sum] = "649294d2064392f0c119f20ce5e5a54855d9696d35e3a37df0b1bfdc32cbb189"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-config-generic-107-11.el10.aarch64.rpm;name=aarch64_dracut-config-generic;unpack=0"
SRC_URI[aarch64_dracut-config-generic.sha256sum] = "16743966550dc252acee2137f3f1db0633e601c7b4a83ec8da890f9edf3e82cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-config-rescue-107-11.el10.aarch64.rpm;name=aarch64_dracut-config-rescue;unpack=0"
SRC_URI[aarch64_dracut-config-rescue.sha256sum] = "a97665a33e7eb95b416d04fae76f1fc6b99018f7cb18fb500e98b6ee930526d3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dracut-live-107-11.el10.aarch64.rpm;name=aarch64_dracut-live;unpack=0"
SRC_URI[aarch64_dracut-live.sha256sum] = "eaa27fb0481df281c3f8bc48f380d7deee40b0134a6fde8197b9f8f986e3f6be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-network-107-11.el10.aarch64.rpm;name=aarch64_dracut-network;unpack=0"
SRC_URI[aarch64_dracut-network.sha256sum] = "ec78df4e8fa7a9279f91c22079b458db7202e3bb964086fda00addb9a0140f8f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-squash-107-11.el10.aarch64.rpm;name=aarch64_dracut-squash;unpack=0"
SRC_URI[aarch64_dracut-squash.sha256sum] = "b58edb59de5be9889d540ad21b696141ab8afe760ca5c0050cec6782ba15166a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-tools-107-11.el10.aarch64.rpm;name=aarch64_dracut-tools;unpack=0"
SRC_URI[aarch64_dracut-tools.sha256sum] = "b9e28d44e6e306fade267d496dc72211de12070060fa95ad36a22cbdf20f4ed5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/dracut-107-11.el10.riscv64.rpm;name=riscv64_dracut;unpack=0"
SRC_URI[riscv64_dracut.sha256sum] = "f8ed1455038c834b4bdac91b457a2127ba5b2a2c32e64472fd9e0a4db9114fc1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/dracut-caps-107-11.el10.riscv64.rpm;name=riscv64_dracut-caps;unpack=0"
SRC_URI[riscv64_dracut-caps.sha256sum] = "792e85619a4df1c0b0e9e247bce8180c6b98555b0d6c519d426dfad78a10569a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/dracut-config-generic-107-11.el10.riscv64.rpm;name=riscv64_dracut-config-generic;unpack=0"
SRC_URI[riscv64_dracut-config-generic.sha256sum] = "1813f96403a3dd307caa4f204c04549f462b8a79cba5ffd932124c7d4f0e3c1b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/dracut-config-rescue-107-11.el10.riscv64.rpm;name=riscv64_dracut-config-rescue;unpack=0"
SRC_URI[riscv64_dracut-config-rescue.sha256sum] = "db3028d35daab3e29f4319671b4a31f22dd623d517b2177db082609e07b83c30"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/dracut-live-107-11.el10.riscv64.rpm;name=riscv64_dracut-live;unpack=0"
SRC_URI[riscv64_dracut-live.sha256sum] = "a3e3963c9ffcc55e4b42bd5443682d274bb19f39733544205c65d08a9750bc0e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/dracut-network-107-11.el10.riscv64.rpm;name=riscv64_dracut-network;unpack=0"
SRC_URI[riscv64_dracut-network.sha256sum] = "6f2109a3a9ebecc35084b8fbcc4e1ea0a036b3bd6e7779df7bb1340448e08046"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/dracut-squash-107-11.el10.riscv64.rpm;name=riscv64_dracut-squash;unpack=0"
SRC_URI[riscv64_dracut-squash.sha256sum] = "1b262c1839d324f2303dfaf7e0fd75b978d1f94a0df3be5699c15d08641bf4f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/dracut-tools-107-11.el10.riscv64.rpm;name=riscv64_dracut-tools;unpack=0"
SRC_URI[riscv64_dracut-tools.sha256sum] = "444ff8b921dde61fa050308bb10fa071ad41488bc0249a94b9661e2eec71dd02"

RDEPENDS:dracut = " \
 bash \
 cpio \
 filesystem \
 findutils \
 glibc \
 grep \
 gzip \
 kmod \
 kmod-libs \
 libgcc \
 libkcapi-hmaccalc \
 openssl-libs \
 procps-ng \
 sed \
 systemd \
 systemd-udev \
 tpm2-tools \
 util-linux \
 util-linux-core \
 virtual/coreutils \
 xz \
 "
RDEPENDS:dracut-caps:x86_64_v2 = " \
 bash \
 dracut \
 libcap \
"
RDEPENDS:dracut-caps:aarch64 = " \
 bash \
 dracut \
"
RDEPENDS:dracut-caps:riscv64 = " \
 bash \
 dracut \
"
RDEPENDS:dracut-config-generic = " \
 dracut \
 "
RDEPENDS:dracut-config-rescue = " \
 bash \
 dracut \
 "
RDEPENDS:dracut-live = " \
 bash \
 curl \
 device-mapper \
 dracut \
 dracut-network \
 gzip \
 parted \
 tar \
 virtual/coreutils \
 "
RDEPENDS:dracut-network = " \
 NetworkManager \
 bash \
 dracut \
 iproute \
 iputils \
 jq \
 "
RDEPENDS:dracut-squash = " \
 bash \
 dracut \
 erofs-utils \
 "
RDEPENDS:dracut-tools = " \
 bash \
 dracut \
 "
