# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ModemManager"
PV = "1.22.0"
PR = "7.el10"
PACKAGES = " \
 ModemManager \
 ModemManager-devel \
 ModemManager-glib \
 ModemManager-glib-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ModemManager-1.22.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e9cf54182e0ec05cde45bb50851eeee3ca2047a1a296a15d5256b6b2deac03a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ModemManager-1.22.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_ModemManager;unpack=0"
SRC_URI[x86_64_v2_ModemManager.sha256sum] = "6d560e37b61bf800c979f7a39872f5fad79f069e9fe94c98f43bbd1ab7a69ec9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ModemManager-devel-1.22.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_ModemManager-devel;unpack=0"
SRC_URI[x86_64_v2_ModemManager-devel.sha256sum] = "8a312b6c1018702a16e9c7f4ab0024bbc72147477e8d3050837a274d00b8578c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ModemManager-glib-1.22.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_ModemManager-glib;unpack=0"
SRC_URI[x86_64_v2_ModemManager-glib.sha256sum] = "38776da22fab192c3662ed67c079664b8916289b945f42bdf4c31297ffde62d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ModemManager-glib-devel-1.22.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_ModemManager-glib-devel;unpack=0"
SRC_URI[x86_64_v2_ModemManager-glib-devel.sha256sum] = "480520a2ff7a7db12d3c699a59b128fce05ecb7258123bfc4d4364d13914ba6f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ModemManager-1.22.0-7.el10.aarch64.rpm;name=aarch64_ModemManager;unpack=0"
SRC_URI[aarch64_ModemManager.sha256sum] = "0d6a6cd9fc5f4909f4b177492e185d67fa05ad6336cc46f8ed61bcc6bb9d90e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ModemManager-devel-1.22.0-7.el10.aarch64.rpm;name=aarch64_ModemManager-devel;unpack=0"
SRC_URI[aarch64_ModemManager-devel.sha256sum] = "87eaea271b341d9b76e4e3ca454c821131d40c76bbf81dc7034df787f01e0608"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ModemManager-glib-1.22.0-7.el10.aarch64.rpm;name=aarch64_ModemManager-glib;unpack=0"
SRC_URI[aarch64_ModemManager-glib.sha256sum] = "af023d55faf6dfc0b5ffc2d812e2819d8022c68dbd2d1fa32a88c567c2aad9d6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ModemManager-glib-devel-1.22.0-7.el10.aarch64.rpm;name=aarch64_ModemManager-glib-devel;unpack=0"
SRC_URI[aarch64_ModemManager-glib-devel.sha256sum] = "1dca6a0854aff95715f87e90c387cb13e599f74f9d029cee07f6aa26850bd7d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/ModemManager-1.22.0-7.el10.riscv64.rpm;name=riscv64_ModemManager;unpack=0"
SRC_URI[riscv64_ModemManager.sha256sum] = "5a73486f320e5e72d0f835f917e0d9dea039071ef1cf458663d3180dcb196066"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/ModemManager-devel-1.22.0-7.el10.riscv64.rpm;name=riscv64_ModemManager-devel;unpack=0"
SRC_URI[riscv64_ModemManager-devel.sha256sum] = "84b34771adc508050af3ff50af5e534b1913aecf9230050f93611a05cfd8995a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/ModemManager-glib-1.22.0-7.el10.riscv64.rpm;name=riscv64_ModemManager-glib;unpack=0"
SRC_URI[riscv64_ModemManager-glib.sha256sum] = "711f5d02468a1cf738e9c5d3c0ddece69b2e978102ad816c1ad5d3abfee4ed36"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/ModemManager-glib-devel-1.22.0-7.el10.riscv64.rpm;name=riscv64_ModemManager-glib-devel;unpack=0"
SRC_URI[riscv64_ModemManager-glib-devel.sha256sum] = "ca81cb19187475d04b5538bf6474656445528bf655b5439fc6578bbf61155bee"

RDEPENDS:ModemManager = " \
 ModemManager-glib \
 bash \
 glib2 \
 glibc \
 libgcc \
 libgudev \
 libmbim \
 libmbim-utils \
 libqmi \
 libqmi-utils \
 libqrtr-glib \
 polkit \
 polkit-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:ModemManager-devel = " \
 ModemManager \
 pkgconf-pkg-config \
 "
RDEPENDS:ModemManager-glib = " \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:ModemManager-glib-devel = " \
 ModemManager \
 ModemManager-devel \
 ModemManager-glib \
 glib2-devel \
 pkgconf-pkg-config \
 "
