# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "logrotate"
PV = "3.22.0"
PR = "5.el10"
PACKAGES = " \
 logrotate \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/logrotate-3.22.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2104020319878d6dfea57c6100187ea5f4b757ca061895771e70205fd4035bca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/logrotate-3.22.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_logrotate;unpack=0"
SRC_URI[x86_64_v2_logrotate.sha256sum] = "8c6527c2bfb8e23f15692ad217acc7b06bdd648f0f9425c5c5bbbf9c5e9e2ddd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/logrotate-3.22.0-5.el10.aarch64.rpm;name=aarch64_logrotate;unpack=0"
SRC_URI[aarch64_logrotate.sha256sum] = "f523ab30f811d4e1a6461da8d57cc274dd26f88abeaae330b3305b9ada829035"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/logrotate-3.22.0-5.el10.riscv64.rpm;name=riscv64_logrotate;unpack=0"
SRC_URI[riscv64_logrotate.sha256sum] = "0243d27890653d2a74668f42d787ddeeefae9b47b9650d19e3e871bb6b6705a5"

RDEPENDS:logrotate = " \
 bash \
 glibc \
 libacl \
 libselinux \
 popt \
 systemd \
 virtual/coreutils \
 "
