# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc-toolset-15-gcc"
PV = "15.2.1"
PR = "8.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 gcc-toolset-15-gcc \
 gcc-toolset-15-gcc-c++ \
 gcc-toolset-15-gcc-gfortran \
 gcc-toolset-15-gcc-plugin-annobin \
 gcc-toolset-15-gcc-plugin-devel \
 gcc-toolset-15-libasan-devel \
 gcc-toolset-15-libatomic-devel \
 gcc-toolset-15-libgccjit \
 gcc-toolset-15-libgccjit-devel \
 gcc-toolset-15-libitm-devel \
 gcc-toolset-15-liblsan-devel \
 gcc-toolset-15-libquadmath-devel \
 gcc-toolset-15-libstdc++-devel \
 gcc-toolset-15-libstdc++-docs \
 gcc-toolset-15-libtsan-devel \
 gcc-toolset-15-libubsan-devel \
 gcc-toolset-15-offload-nvptx \
"
PACKAGES:aarch64 = " \
 gcc-toolset-15-gcc \
 gcc-toolset-15-gcc-c++ \
 gcc-toolset-15-gcc-gfortran \
 gcc-toolset-15-gcc-plugin-annobin \
 gcc-toolset-15-gcc-plugin-devel \
 gcc-toolset-15-libasan-devel \
 gcc-toolset-15-libatomic-devel \
 gcc-toolset-15-libgccjit \
 gcc-toolset-15-libgccjit-devel \
 gcc-toolset-15-libitm-devel \
 gcc-toolset-15-liblsan-devel \
 gcc-toolset-15-libstdc++-devel \
 gcc-toolset-15-libstdc++-docs \
 gcc-toolset-15-libtsan-devel \
 gcc-toolset-15-libubsan-devel \
"
PACKAGES:riscv64 = " \
 gcc-toolset-15-gcc \
 gcc-toolset-15-gcc-c++ \
 gcc-toolset-15-gcc-gfortran \
 gcc-toolset-15-gcc-plugin-annobin \
 gcc-toolset-15-gcc-plugin-devel \
 gcc-toolset-15-libasan-devel \
 gcc-toolset-15-libatomic-devel \
 gcc-toolset-15-libgccjit \
 gcc-toolset-15-libgccjit-devel \
 gcc-toolset-15-libitm-devel \
 gcc-toolset-15-liblsan-devel \
 gcc-toolset-15-libstdc++-devel \
 gcc-toolset-15-libstdc++-docs \
 gcc-toolset-15-libtsan-devel \
 gcc-toolset-15-libubsan-devel \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gcc-toolset-15-gcc-15.2.1-8.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c074fe90f194f5a0e159c8b3fa2ee0e5cf59305ce97aaa4342cfff260e45588b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-gcc-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-gcc;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-gcc.sha256sum] = "2ddd50bcfbaa46edf7772c14dbb2bb1d66610aa47be6e70bcdbf48500370f2db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-gcc-c++-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-gcc-c++;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-gcc-c++.sha256sum] = "71d50a224005e860362a72c4d14c30cb78290b5a9ecb3682cb1872d17711c879"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-gcc-gfortran-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-gcc-gfortran;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-gcc-gfortran.sha256sum] = "68bfd6c6b5cef7ccbe9a50b50dd36db0a57914fe9e9c94f754e8eb2be09718e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-gcc-plugin-annobin-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-gcc-plugin-annobin;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-gcc-plugin-annobin.sha256sum] = "f7ff56fc0543e890ce9521a711bd48568cee3f6176e032be62d11ea757b2fc91"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-gcc-plugin-devel-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-gcc-plugin-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-gcc-plugin-devel.sha256sum] = "4f25cbe00049c69929cd34d1f249fefa67e40e1440d156b2d07d4d13124713fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libasan-devel-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libasan-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-libasan-devel.sha256sum] = "0b70701882a3d887c2f538dc432b297a32d3c804dcc00d5e7960aa60dfac72eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libatomic-devel-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libatomic-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-libatomic-devel.sha256sum] = "d97eb79b2a64e25cad9d470e99dac44264548e0d5fd946e0ecab2502ef9d5945"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libgccjit-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libgccjit;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-libgccjit.sha256sum] = "21952f341ece3a18beff407d4c53f7ac2c37026a7b3f8bca84557e3f07ffeb70"
RPROVIDES:gcc-toolset-15-libgccjit:append:x86_64_v2 = " virtual/libgccjit.so.0___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libgccjit-devel-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libgccjit-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-libgccjit-devel.sha256sum] = "e3c8a3f5986ffc66f7b4ec792c7015fc62f37eac3f5a7dc3713f41ee0b8649bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libitm-devel-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libitm-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-libitm-devel.sha256sum] = "8e263858c014676c746ef46eb49e845ab5ad1b1c4bd58376e369de5ede041aa6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-liblsan-devel-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-liblsan-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-liblsan-devel.sha256sum] = "276ea1ce34829cf3beeb91909b27086fe50bd1dccae2f9e78a701c9ed74fe8d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libquadmath-devel-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libquadmath-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-libquadmath-devel.sha256sum] = "05c2c2c0cfbbbbc545a5f57f1939f9f5f1629f89c916241beaffe4d68a4a6569"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libstdc++-devel-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libstdc++-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-libstdc++-devel.sha256sum] = "0c615d01c81dbc98b3b4427b9e47168f0b1c3c4c214aab3b0ff545f2a3a8d37d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libstdc++-docs-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libstdc++-docs;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-libstdc++-docs.sha256sum] = "0c9f77ae11efee376f64ea15d028c4ee5adb33d74645f89e4e549a380cd421db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libtsan-devel-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libtsan-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-libtsan-devel.sha256sum] = "d44c5c6fb4bd959685a2f9b25dfd850ec902a6b7e36ce15bfb57396ba25963de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libubsan-devel-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libubsan-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-libubsan-devel.sha256sum] = "7a68dd29a27ff1b4729426f598779486b5828ec7b0ae92ccd04d9d519ecc2c2f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-offload-nvptx-15.2.1-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-offload-nvptx;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-15-offload-nvptx.sha256sum] = "0eb3848903ba6bb184c9cd5c8bd7ca315ea17cfcf755d61e24fb1c6f9afe1589"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-gcc-15.2.1-8.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-gcc;unpack=0"
SRC_URI[aarch64_gcc-toolset-15-gcc.sha256sum] = "46725f3ae814f0c6c690deb4771dec73895749e1b86ba4b85b905b022b2f6f7d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-gcc-c++-15.2.1-8.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-gcc-c++;unpack=0"
SRC_URI[aarch64_gcc-toolset-15-gcc-c++.sha256sum] = "8cc0640c493e1257eda4beb04670f716e5d4114073a5536f77753f100edba2b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-gcc-gfortran-15.2.1-8.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-gcc-gfortran;unpack=0"
SRC_URI[aarch64_gcc-toolset-15-gcc-gfortran.sha256sum] = "d41d9ece542ae06f4d0ccd0087a63a92ee7b71b90e98c9209c98ab63660863df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-gcc-plugin-annobin-15.2.1-8.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-gcc-plugin-annobin;unpack=0"
SRC_URI[aarch64_gcc-toolset-15-gcc-plugin-annobin.sha256sum] = "dcda3896e91cc822608f7107d3de7154f4652a50e6eab7bdfaf831bc17c3b527"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-gcc-plugin-devel-15.2.1-8.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-gcc-plugin-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-15-gcc-plugin-devel.sha256sum] = "3322e8eaadc3720c1c993b622c3bed1ea3cf277af0d06428e8f7bb4c902e0247"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libasan-devel-15.2.1-8.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libasan-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-15-libasan-devel.sha256sum] = "db0099669719c8a9fe903eeddb2c3c498faf44354c7faa545edd13ab78ce26d8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libatomic-devel-15.2.1-8.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libatomic-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-15-libatomic-devel.sha256sum] = "53348216917564c383beea2934a6a194f46340c22f0c81b733032875d1654395"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libgccjit-15.2.1-8.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libgccjit;unpack=0"
SRC_URI[aarch64_gcc-toolset-15-libgccjit.sha256sum] = "8805035f33f178c7ff3e21bb1e6a575b13923998f2098320ad0928b271ebd4ec"
RPROVIDES:gcc-toolset-15-libgccjit:append:aarch64 = " virtual/libgccjit.so.0___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libgccjit-devel-15.2.1-8.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libgccjit-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-15-libgccjit-devel.sha256sum] = "4482fe579e538c2b298b7c1c47c19ecd55e2f796771e41dd5531e5a56eccb76e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libitm-devel-15.2.1-8.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libitm-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-15-libitm-devel.sha256sum] = "2da9971ed5599e827f32f64caa0ad1ba3c6fdfd5dc33c1cdacdbcdbcbae14852"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-liblsan-devel-15.2.1-8.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-liblsan-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-15-liblsan-devel.sha256sum] = "e5153784509fa0c8d7e01f4c492b0d9aa22d1f6cabce9716245491114da59b28"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libstdc++-devel-15.2.1-8.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libstdc++-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-15-libstdc++-devel.sha256sum] = "22297e1142d73ae4f8912ed69acd4595997ca83a8c907aac61ec7ad52ee30c05"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libstdc++-docs-15.2.1-8.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libstdc++-docs;unpack=0"
SRC_URI[aarch64_gcc-toolset-15-libstdc++-docs.sha256sum] = "872c002d3f13c6d477163358a6e8a22c02f2eafa9d813d27f7c8559e0eee4afa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libtsan-devel-15.2.1-8.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libtsan-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-15-libtsan-devel.sha256sum] = "b9c92b6b6edb7874701ed8ca8d5fad6488c09a05a8fafda9f254aeb9433fb314"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libubsan-devel-15.2.1-8.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libubsan-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-15-libubsan-devel.sha256sum] = "9fd6b3d418fac246f00ae4adc428d607dd9f087c3f37ece0c8028184d67f7119"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gcc-toolset-15-gcc-15.2.1-8.el10.alma.1.riscv64.rpm;name=riscv64_gcc-toolset-15-gcc;unpack=0"
SRC_URI[riscv64_gcc-toolset-15-gcc.sha256sum] = "ce2c85c2192a0a37447c8aaafb698898cebd3411fc61aa8aa8a167921a911e52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gcc-toolset-15-gcc-c++-15.2.1-8.el10.alma.1.riscv64.rpm;name=riscv64_gcc-toolset-15-gcc-c++;unpack=0"
SRC_URI[riscv64_gcc-toolset-15-gcc-c++.sha256sum] = "cb01c37ad91721c0934bde5745a34e62c885286a55cbbe3a7ff90b16e6139f8d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gcc-toolset-15-gcc-gfortran-15.2.1-8.el10.alma.1.riscv64.rpm;name=riscv64_gcc-toolset-15-gcc-gfortran;unpack=0"
SRC_URI[riscv64_gcc-toolset-15-gcc-gfortran.sha256sum] = "b53dfbde7f9d2dce385e7f1a18122ec3e4a5179b77ee66fea56760750147dd08"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gcc-toolset-15-gcc-plugin-annobin-15.2.1-8.el10.alma.1.riscv64.rpm;name=riscv64_gcc-toolset-15-gcc-plugin-annobin;unpack=0"
SRC_URI[riscv64_gcc-toolset-15-gcc-plugin-annobin.sha256sum] = "aa0ce5fc88204fd6ad01b6e1b48f92e98640ffa1032b19cc81e3fb9555bc95c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gcc-toolset-15-gcc-plugin-devel-15.2.1-8.el10.alma.1.riscv64.rpm;name=riscv64_gcc-toolset-15-gcc-plugin-devel;unpack=0"
SRC_URI[riscv64_gcc-toolset-15-gcc-plugin-devel.sha256sum] = "30b691e103817ce18a7325d0d889a13a444aae618c3839c99309c5943e84472a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gcc-toolset-15-libasan-devel-15.2.1-8.el10.alma.1.riscv64.rpm;name=riscv64_gcc-toolset-15-libasan-devel;unpack=0"
SRC_URI[riscv64_gcc-toolset-15-libasan-devel.sha256sum] = "1f80aec7ac14d2f1b2830eeca15252350f4815b9b1e744a7aa06e39b4e43c06d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gcc-toolset-15-libatomic-devel-15.2.1-8.el10.alma.1.riscv64.rpm;name=riscv64_gcc-toolset-15-libatomic-devel;unpack=0"
SRC_URI[riscv64_gcc-toolset-15-libatomic-devel.sha256sum] = "3ab249dc54e6cb5c7d255df298ab8bdefb87a7eb4d81071fa5125cc1bad6cee8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gcc-toolset-15-libgccjit-15.2.1-8.el10.alma.1.riscv64.rpm;name=riscv64_gcc-toolset-15-libgccjit;unpack=0"
SRC_URI[riscv64_gcc-toolset-15-libgccjit.sha256sum] = "8e30d48fb429df1d942d62fe29c07243aaed4fe55d637609d8e8f1c2fe89f028"
RPROVIDES:gcc-toolset-15-libgccjit:append:riscv64 = " virtual/libgccjit.so.0___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gcc-toolset-15-libgccjit-devel-15.2.1-8.el10.alma.1.riscv64.rpm;name=riscv64_gcc-toolset-15-libgccjit-devel;unpack=0"
SRC_URI[riscv64_gcc-toolset-15-libgccjit-devel.sha256sum] = "5bd1421f3c40af0c39d0a2db0dcfa4d77e0b65a2d1f0dead6e65136552ffe9fd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gcc-toolset-15-libitm-devel-15.2.1-8.el10.alma.1.riscv64.rpm;name=riscv64_gcc-toolset-15-libitm-devel;unpack=0"
SRC_URI[riscv64_gcc-toolset-15-libitm-devel.sha256sum] = "c292599f3b8bbfaed1b5a5c5b1ba4f428d0b31d0e27dbc42e2e43719684ea735"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gcc-toolset-15-liblsan-devel-15.2.1-8.el10.alma.1.riscv64.rpm;name=riscv64_gcc-toolset-15-liblsan-devel;unpack=0"
SRC_URI[riscv64_gcc-toolset-15-liblsan-devel.sha256sum] = "6d0c254a0be82a138aa2e15af88ce9b927e65e154ae77b4e89f1e350fa9be382"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gcc-toolset-15-libstdc++-devel-15.2.1-8.el10.alma.1.riscv64.rpm;name=riscv64_gcc-toolset-15-libstdc++-devel;unpack=0"
SRC_URI[riscv64_gcc-toolset-15-libstdc++-devel.sha256sum] = "ccd98c58a6fda06118ebfa23dcc8d254d560792c4b429c3731c9e1183e783c58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gcc-toolset-15-libstdc++-docs-15.2.1-8.el10.alma.1.riscv64.rpm;name=riscv64_gcc-toolset-15-libstdc++-docs;unpack=0"
SRC_URI[riscv64_gcc-toolset-15-libstdc++-docs.sha256sum] = "228a5d1ef886862e61123ec113545ce02186a7245963a551ea52baab858e3963"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gcc-toolset-15-libtsan-devel-15.2.1-8.el10.alma.1.riscv64.rpm;name=riscv64_gcc-toolset-15-libtsan-devel;unpack=0"
SRC_URI[riscv64_gcc-toolset-15-libtsan-devel.sha256sum] = "6f6cb8f9388fc8db72f7c4d2ba0b848e0a5f7224e0581623f3e3926089379e5d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gcc-toolset-15-libubsan-devel-15.2.1-8.el10.alma.1.riscv64.rpm;name=riscv64_gcc-toolset-15-libubsan-devel;unpack=0"
SRC_URI[riscv64_gcc-toolset-15-libubsan-devel.sha256sum] = "51082f91b5a6e56f5d1b1ba05759060551249930ed3c6150aa9a8a3851c63f03"

RDEPENDS:gcc-toolset-15-gcc:x86_64_v2 = " \
 bash \
 gcc-toolset-15-binutils \
 gcc-toolset-15-runtime \
 glibc \
 glibc-devel \
 gmp \
 libgcc \
 libgomp \
 libmpc \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-15-gcc:aarch64 = " \
 gcc-toolset-15-binutils \
 gcc-toolset-15-runtime \
 glibc \
 glibc-devel \
 gmp \
 libgcc \
 libgomp \
 libmpc \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-15-gcc:riscv64 = " \
 gcc-toolset-15-binutils \
 gcc-toolset-15-runtime \
 glibc \
 glibc-devel \
 gmp \
 libgcc \
 libgomp \
 libmpc \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-15-gcc-c++ = " \
 gcc-toolset-15-gcc \
 gcc-toolset-15-libstdc++-devel \
 glibc \
 gmp \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-15-gcc-gfortran:x86_64_v2 = " \
 bash \
 gcc-toolset-15-gcc \
 gcc-toolset-15-libquadmath-devel \
 glibc \
 gmp \
 info \
 libgfortran \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-15-gcc-gfortran:aarch64 = " \
 bash \
 gcc-toolset-15-gcc \
 glibc \
 gmp \
 info \
 libgfortran \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-15-gcc-gfortran:riscv64 = " \
 bash \
 gcc-toolset-15-gcc \
 glibc \
 gmp \
 info \
 libgfortran \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-15-gcc-plugin-annobin = " \
 gcc-toolset-15-gcc \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gcc-toolset-15-gcc-plugin-devel = " \
 gcc-toolset-15-gcc \
 glibc \
 gmp-devel \
 libmpc-devel \
 mpfr-devel \
 "
RDEPENDS:gcc-toolset-15-libasan-devel = " \
 libasan \
 "
RDEPENDS:gcc-toolset-15-libatomic-devel = " \
 libatomic \
 "
RDEPENDS:gcc-toolset-15-libgccjit = " \
 gcc-toolset-15-gcc \
 glibc \
 gmp \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-15-libgccjit-devel = " \
 gcc-toolset-15-libgccjit \
 "
RDEPENDS:gcc-toolset-15-libitm-devel = " \
 gcc-toolset-15-gcc \
 libitm \
 "
RDEPENDS:gcc-toolset-15-liblsan-devel = " \
 liblsan \
 "
RDEPENDS:gcc-toolset-15-libquadmath-devel = " \
 gcc-toolset-15-gcc \
 libquadmath \
 "
RDEPENDS:gcc-toolset-15-libstdc++-devel = " \
 libstdc++ \
 "
RDEPENDS:gcc-toolset-15-libstdc++-docs = " \
 "
RDEPENDS:gcc-toolset-15-libtsan-devel = " \
 libtsan \
 "
RDEPENDS:gcc-toolset-15-libubsan-devel = " \
 libubsan \
 "
RDEPENDS:gcc-toolset-15-offload-nvptx = " \
 gcc \
 glibc \
 gmp \
 libgcc \
 libgomp-offload-nvptx \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
