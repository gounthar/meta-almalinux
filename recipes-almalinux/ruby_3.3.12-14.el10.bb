# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby"
PV = "3.3.12"
PR = "14.el10"
PACKAGES = " \
 ruby \
 ruby-bundled-gems \
 ruby-default-gems \
 ruby-devel \
 ruby-doc \
 ruby-libs \
 rubygem-bigdecimal \
 rubygem-bundler \
 rubygem-io-console \
 rubygem-irb \
 rubygem-json \
 rubygem-minitest \
 rubygem-power_assert \
 rubygem-psych \
 rubygem-racc \
 rubygem-rake \
 rubygem-rbs \
 rubygem-rdoc \
 rubygem-rexml \
 rubygem-rss \
 rubygem-test-unit \
 rubygem-typeprof \
 rubygems \
 rubygems-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ruby-3.3.12-14.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8dac86412039939535ff2cc4f4873bf7211f0f823de977ceb328694309ba015f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-3.3.12-14.el10.x86_64_v2.rpm;name=x86_64_v2_ruby;unpack=0"
SRC_URI[x86_64_v2_ruby.sha256sum] = "b992dc75465f76fed05790597e5cdf789febebbe17eb94b1a14a42d26bfef158"
RPROVIDES:ruby:append:x86_64_v2 = " virtual/ruby_runtime_executable_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-bundled-gems-3.3.12-14.el10.x86_64_v2.rpm;name=x86_64_v2_ruby-bundled-gems;unpack=0"
SRC_URI[x86_64_v2_ruby-bundled-gems.sha256sum] = "100f1031a9ce0d93d7fbaffcc670ed7bab3917a454cba3a46f0c26cbff9189df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-default-gems-3.3.12-14.el10.noarch.rpm;name=x86_64_v2_ruby-default-gems;unpack=0"
SRC_URI[x86_64_v2_ruby-default-gems.sha256sum] = "0195e0be6cd4e8c4136d0b9a72c3bcf301c3bc45e2379596d131f079a36aaf5e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-devel-3.3.12-14.el10.x86_64_v2.rpm;name=x86_64_v2_ruby-devel;unpack=0"
SRC_URI[x86_64_v2_ruby-devel.sha256sum] = "37266741b2e5935fe60e524ab3f3c990d376ff419fab0573b1d6dc31522c9647"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ruby-doc-3.3.12-14.el10.noarch.rpm;name=x86_64_v2_ruby-doc;unpack=0"
SRC_URI[x86_64_v2_ruby-doc.sha256sum] = "6749ae6ed3ee0ce3c69e0170ee0fa005f9ad79b762180e9c8ad44f0578acbffe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-libs-3.3.12-14.el10.x86_64_v2.rpm;name=x86_64_v2_ruby-libs;unpack=0"
SRC_URI[x86_64_v2_ruby-libs.sha256sum] = "2c2c2860b3f09401421242b1b943abe388cad1f6ccaf0e20d04afa846303d57d"
RPROVIDES:ruby-libs:append:x86_64_v2 = " virtual/ruby_release_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-bigdecimal-3.1.5-14.el10.x86_64_v2.rpm;name=x86_64_v2_rubygem-bigdecimal;unpack=0"
SRC_URI[x86_64_v2_rubygem-bigdecimal.sha256sum] = "29250f3adce0ba6c862a6ba45e6acb4f3210696bad4fac13250029ae154bbd09"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-bundler-2.5.22-14.el10.noarch.rpm;name=x86_64_v2_rubygem-bundler;unpack=0"
SRC_URI[x86_64_v2_rubygem-bundler.sha256sum] = "2a02c9c41d7a0ff13fad99137270951a2a7e8bd7d0bff32dba19f6c9dbcc4748"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-io-console-0.7.1-14.el10.x86_64_v2.rpm;name=x86_64_v2_rubygem-io-console;unpack=0"
SRC_URI[x86_64_v2_rubygem-io-console.sha256sum] = "cec2d719ab7ed2fd274838bc9b6936c33c2f516ee3ea9c5eef2b0c040e06a93e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-irb-1.13.1-14.el10.noarch.rpm;name=x86_64_v2_rubygem-irb;unpack=0"
SRC_URI[x86_64_v2_rubygem-irb.sha256sum] = "30775d93a196e620a6ee3e1fac962be659be96a719091e85cd2b5d177a459a3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-json-2.7.2-14.el10.x86_64_v2.rpm;name=x86_64_v2_rubygem-json;unpack=0"
SRC_URI[x86_64_v2_rubygem-json.sha256sum] = "c6d22bf383fc68d1d9252f4dca82c6dd5ca0cc1fe27d77488dda7545e5cbe0b8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-minitest-5.20.0-14.el10.noarch.rpm;name=x86_64_v2_rubygem-minitest;unpack=0"
SRC_URI[x86_64_v2_rubygem-minitest.sha256sum] = "a6b76fecc19263967c2b5f7d95003379b17050a271a68ffab93d1a2bb145b62b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-power_assert-2.0.3-14.el10.noarch.rpm;name=x86_64_v2_rubygem-power_assert;unpack=0"
SRC_URI[x86_64_v2_rubygem-power_assert.sha256sum] = "869498529102faf261cc8ce885d2a55c6b6f6bc812fe99b2c5140fb4482fb16a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-psych-5.1.2-14.el10.x86_64_v2.rpm;name=x86_64_v2_rubygem-psych;unpack=0"
SRC_URI[x86_64_v2_rubygem-psych.sha256sum] = "aa2aa0b84977efcc48826e5a3764dc8dbcddb03aefb20927b28135ad9cdb08ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-racc-1.7.3-14.el10.x86_64_v2.rpm;name=x86_64_v2_rubygem-racc;unpack=0"
SRC_URI[x86_64_v2_rubygem-racc.sha256sum] = "3b27373e3a5dbcd001188c94337d7be76e01ebe42980a9cd0c63722dc351f1e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rake-13.1.0-14.el10.noarch.rpm;name=x86_64_v2_rubygem-rake;unpack=0"
SRC_URI[x86_64_v2_rubygem-rake.sha256sum] = "717a409280d33e4ec5f301a74530ae1c45b195d9a7cc6149dbd4ae377a7b6adc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rbs-3.4.0-14.el10.x86_64_v2.rpm;name=x86_64_v2_rubygem-rbs;unpack=0"
SRC_URI[x86_64_v2_rubygem-rbs.sha256sum] = "9b2bd32bc5c02cd52b543b5f444e55853c6a6ed234cb5b2111bc90d793fe696e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rdoc-6.6.3.1-14.el10.noarch.rpm;name=x86_64_v2_rubygem-rdoc;unpack=0"
SRC_URI[x86_64_v2_rubygem-rdoc.sha256sum] = "0a85bac1edad1e1bd1fefdcc2641dc3c22bb99577b53569f95dbb6cb8c15e97b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rexml-3.4.4-14.el10.noarch.rpm;name=x86_64_v2_rubygem-rexml;unpack=0"
SRC_URI[x86_64_v2_rubygem-rexml.sha256sum] = "24b311da6562601a7ce6755775e1bc14a7a272a26855d8e036b8271f2cec1478"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rss-0.3.1-14.el10.noarch.rpm;name=x86_64_v2_rubygem-rss;unpack=0"
SRC_URI[x86_64_v2_rubygem-rss.sha256sum] = "fc39e09b45b76aa69efa3ab10a4fe4062eb0dd21c1c4dbb6562bf89fd3fa5d25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-test-unit-3.6.1-14.el10.noarch.rpm;name=x86_64_v2_rubygem-test-unit;unpack=0"
SRC_URI[x86_64_v2_rubygem-test-unit.sha256sum] = "ee6cc894f5dee586ce453ed41ae33466cd15a3a6f7b71418592098cc3c45fc21"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-typeprof-0.21.9-14.el10.noarch.rpm;name=x86_64_v2_rubygem-typeprof;unpack=0"
SRC_URI[x86_64_v2_rubygem-typeprof.sha256sum] = "539451a342dc7072199a7dfc44c307f7c4cf019ba36a4dfe6afb82c68336bfe7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygems-3.5.22-14.el10.noarch.rpm;name=x86_64_v2_rubygems;unpack=0"
SRC_URI[x86_64_v2_rubygems.sha256sum] = "3485ca165ee232c61fd96712783202e8a8c432808fd8fa65221514a266535023"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygems-devel-3.5.22-14.el10.noarch.rpm;name=x86_64_v2_rubygems-devel;unpack=0"
SRC_URI[x86_64_v2_rubygems-devel.sha256sum] = "ff75a645b45a36f40d63d87fbdf7b726ccb0ff1e5feb3bc1e4c7aa0099a6100e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-3.3.12-14.el10.aarch64.rpm;name=aarch64_ruby;unpack=0"
SRC_URI[aarch64_ruby.sha256sum] = "3fd9afe0387e74b0bf7241513be662af749f122ff5a205ceace34012b01117c9"
RPROVIDES:ruby:append:aarch64 = " virtual/ruby_runtime_executable_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-bundled-gems-3.3.12-14.el10.aarch64.rpm;name=aarch64_ruby-bundled-gems;unpack=0"
SRC_URI[aarch64_ruby-bundled-gems.sha256sum] = "53469f50fe4431eb9befd81ca3853ff5d5d68a38754e09e62de27e6ce18d7801"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-default-gems-3.3.12-14.el10.noarch.rpm;name=aarch64_ruby-default-gems;unpack=0"
SRC_URI[aarch64_ruby-default-gems.sha256sum] = "0195e0be6cd4e8c4136d0b9a72c3bcf301c3bc45e2379596d131f079a36aaf5e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-devel-3.3.12-14.el10.aarch64.rpm;name=aarch64_ruby-devel;unpack=0"
SRC_URI[aarch64_ruby-devel.sha256sum] = "4958de2e711915914464fdbc2bce97ec711f4039d5b9e411392ce27028d7aa5f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ruby-doc-3.3.12-14.el10.noarch.rpm;name=aarch64_ruby-doc;unpack=0"
SRC_URI[aarch64_ruby-doc.sha256sum] = "6749ae6ed3ee0ce3c69e0170ee0fa005f9ad79b762180e9c8ad44f0578acbffe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-libs-3.3.12-14.el10.aarch64.rpm;name=aarch64_ruby-libs;unpack=0"
SRC_URI[aarch64_ruby-libs.sha256sum] = "b4dc4f9fc35396029ca393d9b484aff460c6ef26f0a7613737e51b23ca79923f"
RPROVIDES:ruby-libs:append:aarch64 = " virtual/ruby_release_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-bigdecimal-3.1.5-14.el10.aarch64.rpm;name=aarch64_rubygem-bigdecimal;unpack=0"
SRC_URI[aarch64_rubygem-bigdecimal.sha256sum] = "122ee7f542e668b381bd4860208ad56134d7a68166882bd6140d07b1f86881eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-bundler-2.5.22-14.el10.noarch.rpm;name=aarch64_rubygem-bundler;unpack=0"
SRC_URI[aarch64_rubygem-bundler.sha256sum] = "2a02c9c41d7a0ff13fad99137270951a2a7e8bd7d0bff32dba19f6c9dbcc4748"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-io-console-0.7.1-14.el10.aarch64.rpm;name=aarch64_rubygem-io-console;unpack=0"
SRC_URI[aarch64_rubygem-io-console.sha256sum] = "5d5db8c72b9a4dac1cdbf65fd2979742b2397c66355ddc4c79ce6c1543e8dc3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-irb-1.13.1-14.el10.noarch.rpm;name=aarch64_rubygem-irb;unpack=0"
SRC_URI[aarch64_rubygem-irb.sha256sum] = "30775d93a196e620a6ee3e1fac962be659be96a719091e85cd2b5d177a459a3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-json-2.7.2-14.el10.aarch64.rpm;name=aarch64_rubygem-json;unpack=0"
SRC_URI[aarch64_rubygem-json.sha256sum] = "27dfd9b608730a5d5fb7336cadad9335357af8a7915fbd131587ab1c564e8332"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-minitest-5.20.0-14.el10.noarch.rpm;name=aarch64_rubygem-minitest;unpack=0"
SRC_URI[aarch64_rubygem-minitest.sha256sum] = "a6b76fecc19263967c2b5f7d95003379b17050a271a68ffab93d1a2bb145b62b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-power_assert-2.0.3-14.el10.noarch.rpm;name=aarch64_rubygem-power_assert;unpack=0"
SRC_URI[aarch64_rubygem-power_assert.sha256sum] = "869498529102faf261cc8ce885d2a55c6b6f6bc812fe99b2c5140fb4482fb16a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-psych-5.1.2-14.el10.aarch64.rpm;name=aarch64_rubygem-psych;unpack=0"
SRC_URI[aarch64_rubygem-psych.sha256sum] = "3e0294b289a15aa037a4d107f4f3d5ea0ce229c6ae1d18177f10a9d14de16ba3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-racc-1.7.3-14.el10.aarch64.rpm;name=aarch64_rubygem-racc;unpack=0"
SRC_URI[aarch64_rubygem-racc.sha256sum] = "2826c242dfced99c06792cfbb4e422fccab90dbdacd59788fe486c3152bc15cc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rake-13.1.0-14.el10.noarch.rpm;name=aarch64_rubygem-rake;unpack=0"
SRC_URI[aarch64_rubygem-rake.sha256sum] = "717a409280d33e4ec5f301a74530ae1c45b195d9a7cc6149dbd4ae377a7b6adc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rbs-3.4.0-14.el10.aarch64.rpm;name=aarch64_rubygem-rbs;unpack=0"
SRC_URI[aarch64_rubygem-rbs.sha256sum] = "fadbb173a710cee1d74cef9629a00027908afec45d233df303bdc3460404a66a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rdoc-6.6.3.1-14.el10.noarch.rpm;name=aarch64_rubygem-rdoc;unpack=0"
SRC_URI[aarch64_rubygem-rdoc.sha256sum] = "0a85bac1edad1e1bd1fefdcc2641dc3c22bb99577b53569f95dbb6cb8c15e97b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rexml-3.4.4-14.el10.noarch.rpm;name=aarch64_rubygem-rexml;unpack=0"
SRC_URI[aarch64_rubygem-rexml.sha256sum] = "24b311da6562601a7ce6755775e1bc14a7a272a26855d8e036b8271f2cec1478"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rss-0.3.1-14.el10.noarch.rpm;name=aarch64_rubygem-rss;unpack=0"
SRC_URI[aarch64_rubygem-rss.sha256sum] = "fc39e09b45b76aa69efa3ab10a4fe4062eb0dd21c1c4dbb6562bf89fd3fa5d25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-test-unit-3.6.1-14.el10.noarch.rpm;name=aarch64_rubygem-test-unit;unpack=0"
SRC_URI[aarch64_rubygem-test-unit.sha256sum] = "ee6cc894f5dee586ce453ed41ae33466cd15a3a6f7b71418592098cc3c45fc21"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-typeprof-0.21.9-14.el10.noarch.rpm;name=aarch64_rubygem-typeprof;unpack=0"
SRC_URI[aarch64_rubygem-typeprof.sha256sum] = "539451a342dc7072199a7dfc44c307f7c4cf019ba36a4dfe6afb82c68336bfe7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygems-3.5.22-14.el10.noarch.rpm;name=aarch64_rubygems;unpack=0"
SRC_URI[aarch64_rubygems.sha256sum] = "3485ca165ee232c61fd96712783202e8a8c432808fd8fa65221514a266535023"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygems-devel-3.5.22-14.el10.noarch.rpm;name=aarch64_rubygems-devel;unpack=0"
SRC_URI[aarch64_rubygems-devel.sha256sum] = "ff75a645b45a36f40d63d87fbdf7b726ccb0ff1e5feb3bc1e4c7aa0099a6100e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/ruby-3.3.12-14.el10.riscv64.rpm;name=riscv64_ruby;unpack=0"
SRC_URI[riscv64_ruby.sha256sum] = "0f5c59d1e7e73c9ab8454f3aaf2fc50b590abb1f7d147c42ef5e87890fc0e84f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/ruby-bundled-gems-3.3.12-14.el10.riscv64.rpm;name=riscv64_ruby-bundled-gems;unpack=0"
SRC_URI[riscv64_ruby-bundled-gems.sha256sum] = "a47a451edfc3edfd2dba2a238fab133a8939ee646de7feec455808942b3101ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/ruby-default-gems-3.3.12-14.el10.noarch.rpm;name=riscv64_ruby-default-gems;unpack=0"
SRC_URI[riscv64_ruby-default-gems.sha256sum] = "0195e0be6cd4e8c4136d0b9a72c3bcf301c3bc45e2379596d131f079a36aaf5e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/ruby-devel-3.3.12-14.el10.riscv64.rpm;name=riscv64_ruby-devel;unpack=0"
SRC_URI[riscv64_ruby-devel.sha256sum] = "611d7235eec45c6ff8aa24dd9767402d69f16355d6e6e8f10fadb015fdc7bbb8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/ruby-doc-3.3.12-14.el10.noarch.rpm;name=riscv64_ruby-doc;unpack=0"
SRC_URI[riscv64_ruby-doc.sha256sum] = "6749ae6ed3ee0ce3c69e0170ee0fa005f9ad79b762180e9c8ad44f0578acbffe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/ruby-libs-3.3.12-14.el10.riscv64.rpm;name=riscv64_ruby-libs;unpack=0"
SRC_URI[riscv64_ruby-libs.sha256sum] = "623622526a42dfe9edc707e58ed449d3571c8990dec34542095af0fcd7fc9c4e"
RPROVIDES:ruby-libs:append:riscv64 = " virtual/ruby_release_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-bigdecimal-3.1.5-14.el10.riscv64.rpm;name=riscv64_rubygem-bigdecimal;unpack=0"
SRC_URI[riscv64_rubygem-bigdecimal.sha256sum] = "63823a079a8f2f3760ef6ffe083bc9b4b9bfc599f0e56e5889708a8fff3be6db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-bundler-2.5.22-14.el10.noarch.rpm;name=riscv64_rubygem-bundler;unpack=0"
SRC_URI[riscv64_rubygem-bundler.sha256sum] = "2a02c9c41d7a0ff13fad99137270951a2a7e8bd7d0bff32dba19f6c9dbcc4748"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-io-console-0.7.1-14.el10.riscv64.rpm;name=riscv64_rubygem-io-console;unpack=0"
SRC_URI[riscv64_rubygem-io-console.sha256sum] = "97eb4446898ded63de927f510b5938ebe6e0905b4d886bcc07315bbe4fa23507"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-irb-1.13.1-14.el10.noarch.rpm;name=riscv64_rubygem-irb;unpack=0"
SRC_URI[riscv64_rubygem-irb.sha256sum] = "30775d93a196e620a6ee3e1fac962be659be96a719091e85cd2b5d177a459a3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-json-2.7.2-14.el10.riscv64.rpm;name=riscv64_rubygem-json;unpack=0"
SRC_URI[riscv64_rubygem-json.sha256sum] = "f04dfcdf06951ba47261d0cd45d8c2394ab7d2f976509643ddfb06334e1c85e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-minitest-5.20.0-14.el10.noarch.rpm;name=riscv64_rubygem-minitest;unpack=0"
SRC_URI[riscv64_rubygem-minitest.sha256sum] = "a6b76fecc19263967c2b5f7d95003379b17050a271a68ffab93d1a2bb145b62b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-power_assert-2.0.3-14.el10.noarch.rpm;name=riscv64_rubygem-power_assert;unpack=0"
SRC_URI[riscv64_rubygem-power_assert.sha256sum] = "869498529102faf261cc8ce885d2a55c6b6f6bc812fe99b2c5140fb4482fb16a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-psych-5.1.2-14.el10.riscv64.rpm;name=riscv64_rubygem-psych;unpack=0"
SRC_URI[riscv64_rubygem-psych.sha256sum] = "26506838ab274f44ab0c9333fb08f92ba3a5632cc246b22d37d1bf6c747e9651"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-racc-1.7.3-14.el10.riscv64.rpm;name=riscv64_rubygem-racc;unpack=0"
SRC_URI[riscv64_rubygem-racc.sha256sum] = "60d63daea48679022495c7ee0d4976f256e9f82769bb9eb0dec47a7d8b124f39"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-rake-13.1.0-14.el10.noarch.rpm;name=riscv64_rubygem-rake;unpack=0"
SRC_URI[riscv64_rubygem-rake.sha256sum] = "717a409280d33e4ec5f301a74530ae1c45b195d9a7cc6149dbd4ae377a7b6adc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-rbs-3.4.0-14.el10.riscv64.rpm;name=riscv64_rubygem-rbs;unpack=0"
SRC_URI[riscv64_rubygem-rbs.sha256sum] = "d58745b0fd6e63771d74c1dfdc1f08f63697bb2068559b194a00688f52d43d2a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-rdoc-6.6.3.1-14.el10.noarch.rpm;name=riscv64_rubygem-rdoc;unpack=0"
SRC_URI[riscv64_rubygem-rdoc.sha256sum] = "0a85bac1edad1e1bd1fefdcc2641dc3c22bb99577b53569f95dbb6cb8c15e97b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-rexml-3.4.4-14.el10.noarch.rpm;name=riscv64_rubygem-rexml;unpack=0"
SRC_URI[riscv64_rubygem-rexml.sha256sum] = "24b311da6562601a7ce6755775e1bc14a7a272a26855d8e036b8271f2cec1478"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-rss-0.3.1-14.el10.noarch.rpm;name=riscv64_rubygem-rss;unpack=0"
SRC_URI[riscv64_rubygem-rss.sha256sum] = "fc39e09b45b76aa69efa3ab10a4fe4062eb0dd21c1c4dbb6562bf89fd3fa5d25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-test-unit-3.6.1-14.el10.noarch.rpm;name=riscv64_rubygem-test-unit;unpack=0"
SRC_URI[riscv64_rubygem-test-unit.sha256sum] = "ee6cc894f5dee586ce453ed41ae33466cd15a3a6f7b71418592098cc3c45fc21"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygem-typeprof-0.21.9-14.el10.noarch.rpm;name=riscv64_rubygem-typeprof;unpack=0"
SRC_URI[riscv64_rubygem-typeprof.sha256sum] = "539451a342dc7072199a7dfc44c307f7c4cf019ba36a4dfe6afb82c68336bfe7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygems-3.5.22-14.el10.noarch.rpm;name=riscv64_rubygems;unpack=0"
SRC_URI[riscv64_rubygems.sha256sum] = "3485ca165ee232c61fd96712783202e8a8c432808fd8fa65221514a266535023"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/rubygems-devel-3.5.22-14.el10.noarch.rpm;name=riscv64_rubygems-devel;unpack=0"
SRC_URI[riscv64_rubygems-devel.sha256sum] = "ff75a645b45a36f40d63d87fbdf7b726ccb0ff1e5feb3bc1e4c7aa0099a6100e"

RDEPENDS:ruby = " \
 glibc \
 gmp \
 libxcrypt \
 ruby-libs \
 zlib-ng-compat \
 "
RDEPENDS:ruby-bundled-gems = " \
 glibc \
 ruby \
 ruby-default-gems \
 ruby-libs \
 rubygem-irb \
 rubygems \
 "
RDEPENDS:ruby-default-gems = " \
 ruby \
 ruby-default-gems \
 rubygem-io-console \
 rubygems \
 "
RDEPENDS:ruby-devel = " \
 pkgconf-pkg-config \
 ruby \
 ruby-libs \
 rubygems \
 "
RDEPENDS:ruby-doc = " \
 rubygem-rdoc \
 "
RDEPENDS:ruby-libs:x86_64_v2 = " \
 glibc \
 gmp \
 libffi \
 libgcc \
 libxcrypt \
 openssl-libs \
 zlib-ng-compat \
"
RDEPENDS:ruby-libs:aarch64 = " \
 glibc \
 gmp \
 libffi \
 libgcc \
 libxcrypt \
 openssl-libs \
 zlib-ng-compat \
"
RDEPENDS:ruby-libs:riscv64 = " \
 glibc \
 gmp \
 libffi \
 libxcrypt \
 openssl-libs \
 zlib-ng-compat \
"
RDEPENDS:rubygem-bigdecimal = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-bundler = " \
 ruby \
 rubygem-io-console \
 rubygems \
 "
RDEPENDS:rubygem-io-console = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-irb = " \
 ruby \
 ruby-default-gems \
 rubygem-rdoc \
 rubygems \
 "
RDEPENDS:rubygem-json = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-minitest = " \
 rubygems \
 "
RDEPENDS:rubygem-power_assert = " \
 rubygems \
 "
RDEPENDS:rubygem-psych = " \
 glibc \
 libyaml \
 ruby-default-gems \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-racc = " \
 glibc \
 ruby \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-rake = " \
 ruby \
 rubygems \
 "
RDEPENDS:rubygem-rbs = " \
 glibc \
 ruby \
 ruby-default-gems \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-rdoc = " \
 ruby \
 rubygem-io-console \
 rubygem-json \
 rubygem-psych \
 rubygems \
 "
RDEPENDS:rubygem-rexml = " \
 rubygems \
 "
RDEPENDS:rubygem-rss = " \
 rubygem-rexml \
 rubygems \
 "
RDEPENDS:rubygem-test-unit = " \
 rubygem-power_assert \
 rubygems \
 "
RDEPENDS:rubygem-typeprof = " \
 ruby \
 rubygem-rbs \
 rubygems \
 "
RDEPENDS:rubygems = " \
 ruby \
 rubygem-psych \
 virtual/ruby_release_ \
 "
RDEPENDS:rubygems-devel = " \
 ruby \
 rubygem-json \
 rubygem-rdoc \
 rubygems \
 "
