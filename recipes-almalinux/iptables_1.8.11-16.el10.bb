# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iptables"
PV = "1.8.11"
PR = "16.el10"
PACKAGES = " \
 iptables-devel \
 iptables-libs \
 iptables-nft \
 iptables-nft-services \
 iptables-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iptables-1.8.11-16.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1afbbaba64ce17b920f18e2f9df415fc16be71318cee35b9f329559a6078ca58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-devel-1.8.11-16.el10.x86_64_v2.rpm;name=x86_64_v2_iptables-devel;unpack=0"
SRC_URI[x86_64_v2_iptables-devel.sha256sum] = "447bb00143c3f0193ed14b0d80bec7d2cea7b6fac6e8ebf23dd43f2df32cd3ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iptables-libs-1.8.11-16.el10.x86_64_v2.rpm;name=x86_64_v2_iptables-libs;unpack=0"
SRC_URI[x86_64_v2_iptables-libs.sha256sum] = "0a57a2e86cd66f598dd37bb0e9334ff071c1ab5248dec098871598e3ae5f86ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-nft-1.8.11-16.el10.x86_64_v2.rpm;name=x86_64_v2_iptables-nft;unpack=0"
SRC_URI[x86_64_v2_iptables-nft.sha256sum] = "2a899fb0c2b16292135d44ff8439915f0dd1d9d1739204e5afa36986d8b1e5ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-nft-services-1.8.11-16.el10.noarch.rpm;name=x86_64_v2_iptables-nft-services;unpack=0"
SRC_URI[x86_64_v2_iptables-nft-services.sha256sum] = "0feb862736b7c27076d654276d5345d3c24d77655339dcaae6b933604b04187b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-utils-1.8.11-16.el10.x86_64_v2.rpm;name=x86_64_v2_iptables-utils;unpack=0"
SRC_URI[x86_64_v2_iptables-utils.sha256sum] = "bc88207a88fe9c27e19e3f2bf18864f72359dbe96b86e9bfc0c6a79e24de55c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-devel-1.8.11-16.el10.aarch64.rpm;name=aarch64_iptables-devel;unpack=0"
SRC_URI[aarch64_iptables-devel.sha256sum] = "d359ae4b6dee7b3a226cfc31e96f454793d824f75704af823931a388fe0aa40f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iptables-libs-1.8.11-16.el10.aarch64.rpm;name=aarch64_iptables-libs;unpack=0"
SRC_URI[aarch64_iptables-libs.sha256sum] = "ef5e789ab147de97fa814378f9f47ca71fc41d9b60f10329acbba5acba73b541"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-nft-1.8.11-16.el10.aarch64.rpm;name=aarch64_iptables-nft;unpack=0"
SRC_URI[aarch64_iptables-nft.sha256sum] = "e3b08237db22441f4bcbd04e80d168afda978423fccb213672a2a93de6084e83"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-nft-services-1.8.11-16.el10.noarch.rpm;name=aarch64_iptables-nft-services;unpack=0"
SRC_URI[aarch64_iptables-nft-services.sha256sum] = "0feb862736b7c27076d654276d5345d3c24d77655339dcaae6b933604b04187b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-utils-1.8.11-16.el10.aarch64.rpm;name=aarch64_iptables-utils;unpack=0"
SRC_URI[aarch64_iptables-utils.sha256sum] = "ccf837f829f2a669224facb967d13c6185c753ecb29c0808068da070ef62defe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/iptables-devel-1.8.11-16.el10.riscv64.rpm;name=riscv64_iptables-devel;unpack=0"
SRC_URI[riscv64_iptables-devel.sha256sum] = "29f01909500a8f51860a4a818c30bad3145b17e684d45c3712a264ca377d4ff7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/iptables-libs-1.8.11-16.el10.riscv64.rpm;name=riscv64_iptables-libs;unpack=0"
SRC_URI[riscv64_iptables-libs.sha256sum] = "e57c7d612faddd26ee36d8b8b0660688c018a808ac1ffe254dd9c60ff9552b1a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/iptables-nft-1.8.11-16.el10.riscv64.rpm;name=riscv64_iptables-nft;unpack=0"
SRC_URI[riscv64_iptables-nft.sha256sum] = "15dc3827d45ea147e3c709d301e1becbe4fe17edebc05da8e7b5655c4b3359e3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/iptables-nft-services-1.8.11-16.el10.noarch.rpm;name=riscv64_iptables-nft-services;unpack=0"
SRC_URI[riscv64_iptables-nft-services.sha256sum] = "0feb862736b7c27076d654276d5345d3c24d77655339dcaae6b933604b04187b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/iptables-utils-1.8.11-16.el10.riscv64.rpm;name=riscv64_iptables-utils;unpack=0"
SRC_URI[riscv64_iptables-utils.sha256sum] = "fb9488c799339cbaa17000749a030ae7d3a4b7bdd74040fa74efab536d59c33a"

RDEPENDS:iptables-devel = " \
 iptables-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:iptables-libs = " \
 glibc \
 libnetfilter_conntrack \
 "
RDEPENDS:iptables-nft = " \
 alternatives \
 bash \
 glibc \
 iptables-libs \
 libmnl \
 libnftnl \
 virtual//usr/bin/readlink \
 "
RDEPENDS:iptables-nft-services = " \
 bash \
 iptables-nft \
 "
RDEPENDS:iptables-utils = " \
 bash \
 glibc \
 iptables-nft \
 libnfnetlink \
 libpcap \
 "
