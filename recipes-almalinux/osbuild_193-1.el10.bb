# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osbuild"
PV = "193"
PR = "1.el10"
PACKAGES = " \
 osbuild \
 osbuild-container-selinux \
 osbuild-depsolve-dnf \
 osbuild-initrd \
 osbuild-luks2 \
 osbuild-lvm2 \
 osbuild-ostree \
 osbuild-selinux \
 python3-osbuild \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/osbuild-193-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5961d31c2ae14e39de7fbdc3199ba37a11bdddd2133a484c8d2cba39eda75e84"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-193-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild;unpack=0"
SRC_URI[x86_64_v2_osbuild.sha256sum] = "c7f6ce3682c624410d56031d37c6cbb554439f3d28b84ee73b6b5a0f979cb8c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-container-selinux-193-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-container-selinux;unpack=0"
SRC_URI[x86_64_v2_osbuild-container-selinux.sha256sum] = "062794dd726c5c2158beac64fd5107ac9ac80f62c983e00a49eebb8ecf5681e3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-depsolve-dnf-193-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-depsolve-dnf;unpack=0"
SRC_URI[x86_64_v2_osbuild-depsolve-dnf.sha256sum] = "097c606cdbd89b437920ef7b087f536747bcfe8ed8ffd03891af014b70c2de72"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-initrd-193-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-initrd;unpack=0"
SRC_URI[x86_64_v2_osbuild-initrd.sha256sum] = "58aaded89334d0242701a9b1a057fe12875d2dff1912eefb6f6e178f62f8a524"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-luks2-193-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-luks2;unpack=0"
SRC_URI[x86_64_v2_osbuild-luks2.sha256sum] = "0f4c96853928472d946bae8c23df63f3da0658ef7d88fd9b8b1dc266832e7ae0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-lvm2-193-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-lvm2;unpack=0"
SRC_URI[x86_64_v2_osbuild-lvm2.sha256sum] = "1988ee4f8ade894d6ec9e66178af6111f623180bc1b84693d7b309df58a98b3e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-ostree-193-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-ostree;unpack=0"
SRC_URI[x86_64_v2_osbuild-ostree.sha256sum] = "76dccc04db44d846f1e9433fc8c02f1bed2a07fee7148c844bbf11a7fc80e682"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-selinux-193-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-selinux;unpack=0"
SRC_URI[x86_64_v2_osbuild-selinux.sha256sum] = "5428b7bcfeecd94018a4b533dc285ccdd914645b91715c75286595c3e97eb894"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-osbuild-193-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-osbuild;unpack=0"
SRC_URI[x86_64_v2_python3-osbuild.sha256sum] = "3b34743d83ee3880e8fee1b91572dbb867174391795b6f42c40effccf135dbb2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-193-1.el10.aarch64.rpm;name=aarch64_osbuild;unpack=0"
SRC_URI[aarch64_osbuild.sha256sum] = "fe178ca1426568d195289082c789840402d55c4765cf767e9bf92561bd702d37"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-container-selinux-193-1.el10.aarch64.rpm;name=aarch64_osbuild-container-selinux;unpack=0"
SRC_URI[aarch64_osbuild-container-selinux.sha256sum] = "3f8680e8e09fb17b1b0bab449902dd957536ba5dce07609802b9c52f3938858c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-depsolve-dnf-193-1.el10.aarch64.rpm;name=aarch64_osbuild-depsolve-dnf;unpack=0"
SRC_URI[aarch64_osbuild-depsolve-dnf.sha256sum] = "e2c68e08c09b04166f489def0989f62e7f5bd3623f447eccedda5220911c4db7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-initrd-193-1.el10.aarch64.rpm;name=aarch64_osbuild-initrd;unpack=0"
SRC_URI[aarch64_osbuild-initrd.sha256sum] = "0c9783a266a30437c7ad87a74ccf26a078096e4633377e968cb2c4d300f59c64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-luks2-193-1.el10.aarch64.rpm;name=aarch64_osbuild-luks2;unpack=0"
SRC_URI[aarch64_osbuild-luks2.sha256sum] = "8becd86da4f63b818cb5f20119fe42f503c4831a3e62b781cd306e2959432e36"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-lvm2-193-1.el10.aarch64.rpm;name=aarch64_osbuild-lvm2;unpack=0"
SRC_URI[aarch64_osbuild-lvm2.sha256sum] = "098aaac0cc6f7e87b6ac92798f3c9bf37497a7a98e302cf08803c727a6d09983"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-ostree-193-1.el10.aarch64.rpm;name=aarch64_osbuild-ostree;unpack=0"
SRC_URI[aarch64_osbuild-ostree.sha256sum] = "c2028c6336dd82bbd6909f736603f28d473bca41eb184bee5df4154eb3652c08"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-selinux-193-1.el10.aarch64.rpm;name=aarch64_osbuild-selinux;unpack=0"
SRC_URI[aarch64_osbuild-selinux.sha256sum] = "407666ee556ba49f60bafb8d6fa4dff8d0b8389d19784bbc41379d2cde6f9040"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-osbuild-193-1.el10.aarch64.rpm;name=aarch64_python3-osbuild;unpack=0"
SRC_URI[aarch64_python3-osbuild.sha256sum] = "5a4a9b0859c79056c33b5d387849df5ea869f4a59e181f86d18eb2fce24a1d42"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/osbuild-193-1.el10.riscv64.rpm;name=riscv64_osbuild;unpack=0"
SRC_URI[riscv64_osbuild.sha256sum] = "efbb1e432e96d1f4eeea396205e08c7c635e4aaf32faf35febc777629ee991de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/osbuild-container-selinux-193-1.el10.riscv64.rpm;name=riscv64_osbuild-container-selinux;unpack=0"
SRC_URI[riscv64_osbuild-container-selinux.sha256sum] = "e69cdb14a693494e3d81f0a5fbc7e8a89fc2a24a3b708ff2f570c76c79269520"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/osbuild-depsolve-dnf-193-1.el10.riscv64.rpm;name=riscv64_osbuild-depsolve-dnf;unpack=0"
SRC_URI[riscv64_osbuild-depsolve-dnf.sha256sum] = "3dd0a051eac707c84cbd72c5b2aabda27fc591b00765df1ee857af885c9e0889"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/osbuild-initrd-193-1.el10.riscv64.rpm;name=riscv64_osbuild-initrd;unpack=0"
SRC_URI[riscv64_osbuild-initrd.sha256sum] = "13824d46e78e5c0edc5c5ee0259df418208ffd1e40a835fa3e222b7902ef25e3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/osbuild-luks2-193-1.el10.riscv64.rpm;name=riscv64_osbuild-luks2;unpack=0"
SRC_URI[riscv64_osbuild-luks2.sha256sum] = "9ffcc283105bc65c8ec0830cb28a45a68e9b4f84033f6a2d26a3a89e2ec39134"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/osbuild-lvm2-193-1.el10.riscv64.rpm;name=riscv64_osbuild-lvm2;unpack=0"
SRC_URI[riscv64_osbuild-lvm2.sha256sum] = "4717d75c50140f9f6ef9fea0e9c7fd010dc7b29127a21f959174ae6c229b4168"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/osbuild-ostree-193-1.el10.riscv64.rpm;name=riscv64_osbuild-ostree;unpack=0"
SRC_URI[riscv64_osbuild-ostree.sha256sum] = "8508803007235ea8cf3e3ee7e4ff2ad3bfd29a956921dc0427b2e7d91796300c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/osbuild-selinux-193-1.el10.riscv64.rpm;name=riscv64_osbuild-selinux;unpack=0"
SRC_URI[riscv64_osbuild-selinux.sha256sum] = "dd4cc8f08cbcfcd8a1f63678f82dbd638bdf78480423e771ef5afc1f492e37ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/python3-osbuild-193-1.el10.riscv64.rpm;name=riscv64_python3-osbuild;unpack=0"
SRC_URI[riscv64_python3-osbuild.sha256sum] = "3aebcd7ece389902be70ed309a9f2d664ddfa3d8620596bc6113145efc3e5ea3"

RDEPENDS:osbuild = " \
 bash \
 bubblewrap \
 curl \
 e2fsprogs \
 glibc \
 osbuild-initrd \
 osbuild-selinux \
 policycoreutils \
 python3 \
 python3-librepo \
 python3-osbuild \
 qemu-img \
 skopeo \
 systemd \
 tar \
 util-linux \
 virtual//usr/bin/env \
 virtual/coreutils \
 "
RDEPENDS:osbuild-container-selinux = " \
 bash \
 container-selinux \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:osbuild-depsolve-dnf = " \
 osbuild \
 python3 \
 python3-dnf \
 "
RDEPENDS:osbuild-initrd = " \
 "
RDEPENDS:osbuild-luks2 = " \
 cryptsetup \
 osbuild \
 python3 \
 "
RDEPENDS:osbuild-lvm2 = " \
 lvm2 \
 osbuild \
 python3 \
 "
RDEPENDS:osbuild-ostree = " \
 osbuild \
 ostree \
 python3 \
 rpm-ostree \
 "
RDEPENDS:osbuild-selinux = " \
 bash \
 libselinux-utils \
 osbuild \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:python3-osbuild = " \
 python3 \
 python3-jsonschema \
 "
