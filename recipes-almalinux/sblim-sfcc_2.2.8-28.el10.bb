# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sblim-sfcc"
PV = "2.2.8"
PR = "28.el10"
PACKAGES = " \
 sblim-sfcc \
 sblim-sfcc-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sblim-sfcc-2.2.8-28.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e72e694721433286e0cce29a80b1a4d5f10e05288f4ee69aa39efdab5e958eb2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sblim-sfcc-2.2.8-28.el10.x86_64_v2.rpm;name=x86_64_v2_sblim-sfcc;unpack=0"
SRC_URI[x86_64_v2_sblim-sfcc.sha256sum] = "9c1c6d4652ff83f4dcc27a443844ea869dc53786a45052205eea5a62d4a4d4dd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/sblim-sfcc-devel-2.2.8-28.el10.x86_64_v2.rpm;name=x86_64_v2_sblim-sfcc-devel;unpack=0"
SRC_URI[x86_64_v2_sblim-sfcc-devel.sha256sum] = "d6ff03f49dda36b92b56e7d68d4784efd59a8a7c08bfed93b405811155de03de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sblim-sfcc-2.2.8-28.el10.aarch64.rpm;name=aarch64_sblim-sfcc;unpack=0"
SRC_URI[aarch64_sblim-sfcc.sha256sum] = "b09ee01a0eb806d8bf610448016c904f41a8601b0d348f0083d13e86fd891ff7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/sblim-sfcc-devel-2.2.8-28.el10.aarch64.rpm;name=aarch64_sblim-sfcc-devel;unpack=0"
SRC_URI[aarch64_sblim-sfcc-devel.sha256sum] = "6e1129429a0f5920373079cc52c87c24f14264a84434c28eeb1c7caaa201002c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/sblim-sfcc-2.2.8-28.el10.riscv64.rpm;name=riscv64_sblim-sfcc;unpack=0"
SRC_URI[riscv64_sblim-sfcc.sha256sum] = "dba0b45f819363768af1e2d42f1ade9dcf515295b171f30efd9d979ccc701a3a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/sblim-sfcc-devel-2.2.8-28.el10.riscv64.rpm;name=riscv64_sblim-sfcc-devel;unpack=0"
SRC_URI[riscv64_sblim-sfcc-devel.sha256sum] = "5e057efb663dd14c2bdada62c411bceb87138f4cc4d2f2e0b15facd1afe0c5c0"

RDEPENDS:sblim-sfcc = " \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:sblim-sfcc-devel = " \
 sblim-sfcc \
 "
