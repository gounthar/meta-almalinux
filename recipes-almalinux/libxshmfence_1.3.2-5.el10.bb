# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxshmfence"
PV = "1.3.2"
PR = "5.el10"
PACKAGES = " \
 libxshmfence \
 libxshmfence-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libxshmfence-1.3.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "670581bf10f7043772a252c4b73bfdbb039c488d8e5c204941ca1ce36572b49b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxshmfence-1.3.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libxshmfence;unpack=0"
SRC_URI[x86_64_v2_libxshmfence.sha256sum] = "a4e1da66f4497b4080cbefd0ac99b6049c14e810bbf234528b38e212b69b9d3f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxshmfence-devel-1.3.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libxshmfence-devel;unpack=0"
SRC_URI[x86_64_v2_libxshmfence-devel.sha256sum] = "4aa1b8e649cfa3a31f1025746d7888aa029d81fd7ae6761c449bfe792a9ced70"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxshmfence-1.3.2-5.el10.aarch64.rpm;name=aarch64_libxshmfence;unpack=0"
SRC_URI[aarch64_libxshmfence.sha256sum] = "c0507386f7a2ae9de6e6934befa39b11971b8bcfd7ada91a4b6d9077c7ecb60b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxshmfence-devel-1.3.2-5.el10.aarch64.rpm;name=aarch64_libxshmfence-devel;unpack=0"
SRC_URI[aarch64_libxshmfence-devel.sha256sum] = "404b25f2419628eb37ccdc01254bbaa32f5ca5813128035c6846744557ff4262"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libxshmfence-1.3.2-5.el10.riscv64.rpm;name=riscv64_libxshmfence;unpack=0"
SRC_URI[riscv64_libxshmfence.sha256sum] = "2532032e5b9b5a8928dfc0de1342d363cbd54f3803fe4539d69a3570cd796a77"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libxshmfence-devel-1.3.2-5.el10.riscv64.rpm;name=riscv64_libxshmfence-devel;unpack=0"
SRC_URI[riscv64_libxshmfence-devel.sha256sum] = "d3b68c6a342bd9e4d70e7b4bd01b0fc1d6ab09a34e04fbe8ccacd1a17bc6b9e3"

RDEPENDS:libxshmfence = " \
 glibc \
 "
RDEPENDS:libxshmfence-devel = " \
 libxshmfence \
 pkgconf-pkg-config \
 "
