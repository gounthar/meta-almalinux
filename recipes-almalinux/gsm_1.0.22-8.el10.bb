# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gsm"
PV = "1.0.22"
PR = "8.el10"
PACKAGES = " \
 gsm \
 gsm-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gsm-1.0.22-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "46d0c452c95a7c5733f252d53a52406e6ab0046f8b10af670f845167e5108ac8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gsm-1.0.22-8.el10.x86_64_v2.rpm;name=x86_64_v2_gsm;unpack=0"
SRC_URI[x86_64_v2_gsm.sha256sum] = "fc9bc225eb9c0925cbde78a7f588e94d9d4e051bbf733b18b1e86dbcddd97a7e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gsm-devel-1.0.22-8.el10.x86_64_v2.rpm;name=x86_64_v2_gsm-devel;unpack=0"
SRC_URI[x86_64_v2_gsm-devel.sha256sum] = "7dc1db621da6a61a3d9b0e0bbe21a7920b000324ab8b4ea7b793695b81a49874"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gsm-1.0.22-8.el10.aarch64.rpm;name=aarch64_gsm;unpack=0"
SRC_URI[aarch64_gsm.sha256sum] = "b1deefae334901c3c58fdf53b562741979c1769e26cf7bff4ab9df40b98ad3ff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gsm-devel-1.0.22-8.el10.aarch64.rpm;name=aarch64_gsm-devel;unpack=0"
SRC_URI[aarch64_gsm-devel.sha256sum] = "ee3136d9101a5356402d04c894e2d2e67078a747b4f8c0851aa27e5f18905ef3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/gsm-1.0.22-8.el10.riscv64.rpm;name=riscv64_gsm;unpack=0"
SRC_URI[riscv64_gsm.sha256sum] = "0f2b0950f1fbf622e7ada40e7a9c792b22b494e3884c0b9d8e52873bcb0d3025"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/gsm-devel-1.0.22-8.el10.riscv64.rpm;name=riscv64_gsm-devel;unpack=0"
SRC_URI[riscv64_gsm-devel.sha256sum] = "385f1b7cd59ad7cf1cd320f72bc97659e13332d05523494312f370de3bc6148c"

RDEPENDS:gsm = " \
 glibc \
 "
RDEPENDS:gsm-devel = " \
 gsm \
 "
