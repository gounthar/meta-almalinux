# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libspiro"
PV = "20240903"
PR = "3.el10"
PACKAGES = " \
 libspiro \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libspiro-20240903-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f3cb1991b849199b5603b1c7786308beb66801af4a9afb030ea841fbdd10b3ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libspiro-20240903-3.el10.x86_64_v2.rpm;name=x86_64_v2_libspiro;unpack=0"
SRC_URI[x86_64_v2_libspiro.sha256sum] = "0e8e9bfdc75cda605018c45363d7052882297f5f984a4f4ea6d19518d4c0db3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libspiro-20240903-3.el10.aarch64.rpm;name=aarch64_libspiro;unpack=0"
SRC_URI[aarch64_libspiro.sha256sum] = "b04df30b815ae2ec44fc35abf78acb8a7f464b5f73ff82a47ef94d0dc4b1ebc1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libspiro-20240903-3.el10.riscv64.rpm;name=riscv64_libspiro;unpack=0"
SRC_URI[riscv64_libspiro.sha256sum] = "7cf6f41d6e3e3c9a12a14045f4e39b16a075b9f5b9e91b25374876b978a3ec91"

RDEPENDS:libspiro = " \
 glibc \
 "
