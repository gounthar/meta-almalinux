# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apr-util"
PV = "1.6.3"
PR = "24.el10"
PACKAGES = " \
 apr-util \
 apr-util-devel \
 apr-util-ldap \
 apr-util-lmdb \
 apr-util-mysql \
 apr-util-odbc \
 apr-util-openssl \
 apr-util-pgsql \
 apr-util-sqlite \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/apr-util-1.6.3-24.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "90cfa4d434889825d1622ab5f942da30de162affaa3ec9762c86a9d70e1b09c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-1.6.3-24.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util;unpack=0"
SRC_URI[x86_64_v2_apr-util.sha256sum] = "7978a4e3175b2abc3043cfc8a08e616edf7544595924c6c49790750a0b5af3d3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-devel-1.6.3-24.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-devel;unpack=0"
SRC_URI[x86_64_v2_apr-util-devel.sha256sum] = "9602c627523618204bd59a29cdd090e67b4f8f66b59b4a69c293a53e5e8b3309"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-ldap-1.6.3-24.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-ldap;unpack=0"
SRC_URI[x86_64_v2_apr-util-ldap.sha256sum] = "863038a028a3804d621794d5641ab50f1e325cbd06e911f2ea7e9e14e2ce886d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-lmdb-1.6.3-24.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-lmdb;unpack=0"
SRC_URI[x86_64_v2_apr-util-lmdb.sha256sum] = "fa60382c56cf158d3067320ea66536d3502633bad3a69d5029b0a0d9f7362bd6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-mysql-1.6.3-24.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-mysql;unpack=0"
SRC_URI[x86_64_v2_apr-util-mysql.sha256sum] = "22bd72365ced5525ec1776ea364c5592121ce83cd732be4316169888f9619823"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-odbc-1.6.3-24.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-odbc;unpack=0"
SRC_URI[x86_64_v2_apr-util-odbc.sha256sum] = "d8468b12300db874ea35302edac121e0e9ed44e8d02a112f042f1ebf49456fa1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-openssl-1.6.3-24.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-openssl;unpack=0"
SRC_URI[x86_64_v2_apr-util-openssl.sha256sum] = "ce98495edbd26ade5d9fa342a89713cbfaec83ba199266796c12ddd898ceb8c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-pgsql-1.6.3-24.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-pgsql;unpack=0"
SRC_URI[x86_64_v2_apr-util-pgsql.sha256sum] = "0d57dbceff91c600d1c962a6d0687981cf12b43e403969d6ea125a7d18c65172"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-sqlite-1.6.3-24.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-sqlite;unpack=0"
SRC_URI[x86_64_v2_apr-util-sqlite.sha256sum] = "aa864918ca262486a51b43a687fecfcd8c6c568d8e3db1e1b5f5d6892e06cf29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-1.6.3-24.el10.aarch64.rpm;name=aarch64_apr-util;unpack=0"
SRC_URI[aarch64_apr-util.sha256sum] = "fb9b48d699bfa9d87678e39b8655484dc13a91c73e0bbad779ebc8afe5aa3668"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-devel-1.6.3-24.el10.aarch64.rpm;name=aarch64_apr-util-devel;unpack=0"
SRC_URI[aarch64_apr-util-devel.sha256sum] = "182f5f1cd83b0fd91c6a48a80fe3b027f21d47af6aee6b61675250ca6c9d0edb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-ldap-1.6.3-24.el10.aarch64.rpm;name=aarch64_apr-util-ldap;unpack=0"
SRC_URI[aarch64_apr-util-ldap.sha256sum] = "f6f5ee5c3b4107c8c3e801e2ceee72ab085fe7065f8f03f96354b855b7e68350"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-lmdb-1.6.3-24.el10.aarch64.rpm;name=aarch64_apr-util-lmdb;unpack=0"
SRC_URI[aarch64_apr-util-lmdb.sha256sum] = "133d34ea4aa27caf17e47eadb82773a84fdb013952efd15b5309154a422bddd9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-mysql-1.6.3-24.el10.aarch64.rpm;name=aarch64_apr-util-mysql;unpack=0"
SRC_URI[aarch64_apr-util-mysql.sha256sum] = "cd96304a928ff3d0dd4def256c215b8299c63f8e6675078f5a49b6333fca9438"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-odbc-1.6.3-24.el10.aarch64.rpm;name=aarch64_apr-util-odbc;unpack=0"
SRC_URI[aarch64_apr-util-odbc.sha256sum] = "b2fa6e756cd3a4003a3b1dd300a4eb50eb803cbb1a1f2acf67bc9ca74a7979e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-openssl-1.6.3-24.el10.aarch64.rpm;name=aarch64_apr-util-openssl;unpack=0"
SRC_URI[aarch64_apr-util-openssl.sha256sum] = "c77991f8ea80df5cc9f9ae516f81287d5d8c1d147a4f3dbc431920d73c604e6f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-pgsql-1.6.3-24.el10.aarch64.rpm;name=aarch64_apr-util-pgsql;unpack=0"
SRC_URI[aarch64_apr-util-pgsql.sha256sum] = "68f54d382f678e76b1938d5e67331801af69a7ff3ed337b6ac4f18ba2ad30e2e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-sqlite-1.6.3-24.el10.aarch64.rpm;name=aarch64_apr-util-sqlite;unpack=0"
SRC_URI[aarch64_apr-util-sqlite.sha256sum] = "ce7b30fdd8347272dde23a154224c1d303123c634f2e992c4e6dfc78b1e0386f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/apr-util-1.6.3-24.el10.riscv64.rpm;name=riscv64_apr-util;unpack=0"
SRC_URI[riscv64_apr-util.sha256sum] = "7d50ab496d2e1da04822311fface2b3e176e4c8f15a3ddee93ee3a4f39e1f58b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/apr-util-devel-1.6.3-24.el10.riscv64.rpm;name=riscv64_apr-util-devel;unpack=0"
SRC_URI[riscv64_apr-util-devel.sha256sum] = "c8327d90f93be6e7b54a0998ab9654965f792d7d8b3e04a27460655d17402d50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/apr-util-ldap-1.6.3-24.el10.riscv64.rpm;name=riscv64_apr-util-ldap;unpack=0"
SRC_URI[riscv64_apr-util-ldap.sha256sum] = "6f0bec1977d9dda3c799e9abf824be70688ebb399bd154aa0185f12656a04ff6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/apr-util-lmdb-1.6.3-24.el10.riscv64.rpm;name=riscv64_apr-util-lmdb;unpack=0"
SRC_URI[riscv64_apr-util-lmdb.sha256sum] = "4457adf50a8fd0060d57ec4243a1bd83da5d1c9e7b6c7a51ade1accc96c0dc54"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/apr-util-mysql-1.6.3-24.el10.riscv64.rpm;name=riscv64_apr-util-mysql;unpack=0"
SRC_URI[riscv64_apr-util-mysql.sha256sum] = "c881e270e5577baef655c3ca9226a52574ad3a27de44837897f438131f838710"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/apr-util-odbc-1.6.3-24.el10.riscv64.rpm;name=riscv64_apr-util-odbc;unpack=0"
SRC_URI[riscv64_apr-util-odbc.sha256sum] = "f921805090f944f27814ca5df76de24f968b8aaea4ba5508cd8df142c6d19687"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/apr-util-openssl-1.6.3-24.el10.riscv64.rpm;name=riscv64_apr-util-openssl;unpack=0"
SRC_URI[riscv64_apr-util-openssl.sha256sum] = "d0e5ec4d6ef89fc2c0b77563a70891f79b54cfd312f1f714a1b795f397528c15"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/apr-util-pgsql-1.6.3-24.el10.riscv64.rpm;name=riscv64_apr-util-pgsql;unpack=0"
SRC_URI[riscv64_apr-util-pgsql.sha256sum] = "7e7ca0fe0610883e5dc5ae59f2087b480971685b007bc2c16c73167130d53a5f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/apr-util-sqlite-1.6.3-24.el10.riscv64.rpm;name=riscv64_apr-util-sqlite;unpack=0"
SRC_URI[riscv64_apr-util-sqlite.sha256sum] = "acc3c9a534deb5e29a1f2330d376afc63959e1b0f903266ab52a710eb0e2b0dc"

RDEPENDS:apr-util = " \
 apr \
 expat \
 glibc \
 libuuid \
 libxcrypt \
 "
RDEPENDS:apr-util-devel = " \
 apr-devel \
 apr-util \
 bash \
 expat-devel \
 openldap-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:apr-util-ldap = " \
 apr-util \
 glibc \
 openldap \
 "
RDEPENDS:apr-util-lmdb = " \
 apr-util \
 glibc \
 lmdb-libs \
 "
RDEPENDS:apr-util-mysql = " \
 apr-util \
 glibc \
 mariadb-connector-c \
 "
RDEPENDS:apr-util-odbc = " \
 apr-util \
 glibc \
 unixODBC \
 "
RDEPENDS:apr-util-openssl = " \
 apr-util \
 glibc \
 openssl-libs \
 "
RDEPENDS:apr-util-pgsql = " \
 apr-util \
 glibc \
 libpq \
 "
RDEPENDS:apr-util-sqlite = " \
 apr-util \
 glibc \
 sqlite-libs \
 "
