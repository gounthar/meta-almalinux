# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libburn"
PV = "1.5.6"
PR = "6.el10"
PACKAGES = " \
 cdrskin \
 libburn \
 libburn-devel \
 libburn-doc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libburn-1.5.6-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6b37c285e685c1f386d88179ec3e089bbe9a88f9b1921f423502c08847955da2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cdrskin-1.5.6-6.el10.x86_64_v2.rpm;name=x86_64_v2_cdrskin;unpack=0"
SRC_URI[x86_64_v2_cdrskin.sha256sum] = "be61ba7291778159c80d90e7e8633d7ebf03a560fd8fe6ffeb23f59f881e8549"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libburn-1.5.6-6.el10.x86_64_v2.rpm;name=x86_64_v2_libburn;unpack=0"
SRC_URI[x86_64_v2_libburn.sha256sum] = "32b4cd57ceab528af601635aa15f84c05f5dbfd8701a1506415acdb229cdc5f5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libburn-devel-1.5.6-6.el10.x86_64_v2.rpm;name=x86_64_v2_libburn-devel;unpack=0"
SRC_URI[x86_64_v2_libburn-devel.sha256sum] = "bd3098a63bb600e397523046f7bbd1fb55ff2012e48dc68a9a09e792064d2175"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libburn-doc-1.5.6-6.el10.noarch.rpm;name=x86_64_v2_libburn-doc;unpack=0"
SRC_URI[x86_64_v2_libburn-doc.sha256sum] = "cc266ea41520cee22114788f65c983bb19d3e3f48680388262de7a915ece8a3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cdrskin-1.5.6-6.el10.aarch64.rpm;name=aarch64_cdrskin;unpack=0"
SRC_URI[aarch64_cdrskin.sha256sum] = "2c94655a51e56c538225c494972ee95c93d88314c35c2c0cc1d20ecbceb7d04d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libburn-1.5.6-6.el10.aarch64.rpm;name=aarch64_libburn;unpack=0"
SRC_URI[aarch64_libburn.sha256sum] = "d10af8731cafe5e4a732260167807c46fc3c60295bf5c47af61c86db144566c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libburn-devel-1.5.6-6.el10.aarch64.rpm;name=aarch64_libburn-devel;unpack=0"
SRC_URI[aarch64_libburn-devel.sha256sum] = "24dce65aa05c613e710d0743affe988f536e0f6e8b2baaedb679feae50287b45"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libburn-doc-1.5.6-6.el10.noarch.rpm;name=aarch64_libburn-doc;unpack=0"
SRC_URI[aarch64_libburn-doc.sha256sum] = "cc266ea41520cee22114788f65c983bb19d3e3f48680388262de7a915ece8a3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/cdrskin-1.5.6-6.el10.riscv64.rpm;name=riscv64_cdrskin;unpack=0"
SRC_URI[riscv64_cdrskin.sha256sum] = "213826914c8665a0cff7cfb347421c6b80e220e91514ceb52cc3ba8e4538e62c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libburn-1.5.6-6.el10.riscv64.rpm;name=riscv64_libburn;unpack=0"
SRC_URI[riscv64_libburn.sha256sum] = "8d78e8c0f3daea12d219b7234dafb25315bc35e57d23c739559043f5d1404e21"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/libburn-devel-1.5.6-6.el10.riscv64.rpm;name=riscv64_libburn-devel;unpack=0"
SRC_URI[riscv64_libburn-devel.sha256sum] = "6a85012666f01a114618a56d3a9e14fdbd9a452e674ded63f0c094b245a5c175"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libburn-doc-1.5.6-6.el10.noarch.rpm;name=riscv64_libburn-doc;unpack=0"
SRC_URI[riscv64_libburn-doc.sha256sum] = "cc266ea41520cee22114788f65c983bb19d3e3f48680388262de7a915ece8a3b"

RDEPENDS:cdrskin = " \
 alternatives \
 bash \
 glibc \
 libburn \
 virtual/coreutils \
 "
RDEPENDS:libburn = " \
 glibc \
 "
RDEPENDS:libburn-devel = " \
 libburn \
 pkgconf-pkg-config \
 "
RDEPENDS:libburn-doc = " \
 "
