# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libappstream-glib"
PV = "0.8.3"
PR = "3.el10"
PACKAGES = " \
 libappstream-glib \
 libappstream-glib-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libappstream-glib-0.8.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e0280757c6c4ad00bf0d59a90a017c181aac34098aca3f036a70bb6397be5d32"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libappstream-glib-0.8.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_libappstream-glib;unpack=0"
SRC_URI[x86_64_v2_libappstream-glib.sha256sum] = "089667bfc8ba6de44e2c078bc9fe1a9de064708e39225e0b2c48e25d6311c3ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libappstream-glib-devel-0.8.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_libappstream-glib-devel;unpack=0"
SRC_URI[x86_64_v2_libappstream-glib-devel.sha256sum] = "6df4ca0e618efc3417b4318d0e010f3014f7ad35341f1111a1b6f053203f0b0b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libappstream-glib-0.8.3-3.el10.aarch64.rpm;name=aarch64_libappstream-glib;unpack=0"
SRC_URI[aarch64_libappstream-glib.sha256sum] = "b9aa9454fdae04eeb0ba9d49282762c36a023c3ce27329c49ccb46994e5cd0a9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libappstream-glib-devel-0.8.3-3.el10.aarch64.rpm;name=aarch64_libappstream-glib-devel;unpack=0"
SRC_URI[aarch64_libappstream-glib-devel.sha256sum] = "2ef69a63e39650d18221a1d3201af03d589de8de16ef6b2d44a61dba34de6108"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libappstream-glib-0.8.3-3.el10.riscv64.rpm;name=riscv64_libappstream-glib;unpack=0"
SRC_URI[riscv64_libappstream-glib.sha256sum] = "e4ea3c381c0963449d9c26aee13a3b0fa40fdfdc4902c32c5f635020a7a1b534"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/libappstream-glib-devel-0.8.3-3.el10.riscv64.rpm;name=riscv64_libappstream-glib-devel;unpack=0"
SRC_URI[riscv64_libappstream-glib-devel.sha256sum] = "115da8edfa233f7e9978bf3b55343112bda98a2609e08a8388b97e41da672aa9"

RDEPENDS:libappstream-glib = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 json-glib \
 libarchive \
 libgcc \
 libuuid \
 rpm-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libappstream-glib-devel = " \
 gdk-pixbuf2-devel \
 glib2-devel \
 libappstream-glib \
 libarchive-devel \
 libuuid-devel \
 pkgconf-pkg-config \
 "
