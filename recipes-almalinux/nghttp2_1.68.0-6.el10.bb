# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nghttp2"
PV = "1.68.0"
PR = "6.el10"
PACKAGES = " \
 libnghttp2 \
 libnghttp2-devel \
 nghttp2 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nghttp2-1.68.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d712e16476260c4c16b66d282310a860bf2f052191f8d3c0d2aec3abf7c69b86"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnghttp2-1.68.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_libnghttp2;unpack=0"
SRC_URI[x86_64_v2_libnghttp2.sha256sum] = "7e513f809cba4cb567feba0fc4f89da0811e87ae6c4caaa75dfa6943a98d161e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnghttp2-devel-1.68.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_libnghttp2-devel;unpack=0"
SRC_URI[x86_64_v2_libnghttp2-devel.sha256sum] = "c83511c04c33a177bb56dda45b94bbce8d81fae3586dac43ddc360e36c0751eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nghttp2-1.68.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_nghttp2;unpack=0"
SRC_URI[x86_64_v2_nghttp2.sha256sum] = "41f821c1eb133af19af021b1720c7fd9d262a1f114e2487f49a0d6852c6533e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnghttp2-1.68.0-6.el10.aarch64.rpm;name=aarch64_libnghttp2;unpack=0"
SRC_URI[aarch64_libnghttp2.sha256sum] = "69f6c03e5a98f830db5be8b100a44bfbdf1a762bd83978440c97e34eecf9e7a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnghttp2-devel-1.68.0-6.el10.aarch64.rpm;name=aarch64_libnghttp2-devel;unpack=0"
SRC_URI[aarch64_libnghttp2-devel.sha256sum] = "ef937b558e1e6cf1cf71300c9530c3d5dad08a1243ce6eff2e8c4d8520c80943"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nghttp2-1.68.0-6.el10.aarch64.rpm;name=aarch64_nghttp2;unpack=0"
SRC_URI[aarch64_nghttp2.sha256sum] = "605ccc76c19c392b15adb18c06d1d132c4583ab2a1dc7819407b9d22b6a143e3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/libnghttp2-1.68.0-6.el10.riscv64.rpm;name=riscv64_libnghttp2;unpack=0"
SRC_URI[riscv64_libnghttp2.sha256sum] = "242b9ab2bf4ade037b219944b4c0c4483fc95744ca4574c1ce7cebd7a5660e54"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/libnghttp2-devel-1.68.0-6.el10.riscv64.rpm;name=riscv64_libnghttp2-devel;unpack=0"
SRC_URI[riscv64_libnghttp2-devel.sha256sum] = "c9a9727280a0c6bef79d8798f9ef53e0fc2433e4e3a0e3f47ab2902c51af954e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/riscv64/os/Packages/nghttp2-1.68.0-6.el10.riscv64.rpm;name=riscv64_nghttp2;unpack=0"
SRC_URI[riscv64_nghttp2.sha256sum] = "2f1f4c4c92545afb2d5bf53555231f4fbbfa594576cb7ece21b7b9528e00d2a4"

RDEPENDS:libnghttp2 = " \
 glibc \
 "
RDEPENDS:libnghttp2-devel = " \
 libnghttp2 \
 pkgconf-pkg-config \
 "
RDEPENDS:nghttp2 = " \
 bash \
 c-ares \
 glibc \
 libev \
 libgcc \
 libnghttp2 \
 libstdc++ \
 libxml2 \
 openssl-libs \
 systemd \
 zlib-ng-compat \
 "
