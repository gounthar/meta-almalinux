# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mesa"
PV = "26.1.1"
PR = "2.el10.alma.3"
PACKAGES = " \
 mesa-dri-drivers \
 mesa-filesystem \
 mesa-libEGL \
 mesa-libEGL-devel \
 mesa-libGL \
 mesa-libGL-devel \
 mesa-libgbm \
 mesa-libgbm-devel \
 mesa-vulkan-drivers \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mesa-26.1.1-2.el10.alma.3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8d82f7bf71ff1c61d334ed22732db103c19fa6cacab36fe39f7d82a1bb483436"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-dri-drivers-26.1.1-2.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_mesa-dri-drivers;unpack=0"
SRC_URI[x86_64_v2_mesa-dri-drivers.sha256sum] = "460445cafe3b537324ffdb7aaedef1af22875fc15acb4934b7e2e1fc1a4f8364"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-filesystem-26.1.1-2.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_mesa-filesystem;unpack=0"
SRC_URI[x86_64_v2_mesa-filesystem.sha256sum] = "a916d142d9cd6f1ff9b6eec31feae50b0c7b5a07c6a7f20473cac1ce63301dad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libEGL-26.1.1-2.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_mesa-libEGL;unpack=0"
SRC_URI[x86_64_v2_mesa-libEGL.sha256sum] = "ea404729fe025c6434a064df03f0ab9a5e0f6c78b026ff5edf8fdbad8815c433"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libEGL-devel-26.1.1-2.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_mesa-libEGL-devel;unpack=0"
SRC_URI[x86_64_v2_mesa-libEGL-devel.sha256sum] = "c70b064f54e67ddef7f03eda32e557cb175b82a2b9a30c352eb9ef566d640682"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libGL-26.1.1-2.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_mesa-libGL;unpack=0"
SRC_URI[x86_64_v2_mesa-libGL.sha256sum] = "ea37f1328b04dd29131d94f7680bcd266f69510250bdb384a063092c5803063e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libGL-devel-26.1.1-2.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_mesa-libGL-devel;unpack=0"
SRC_URI[x86_64_v2_mesa-libGL-devel.sha256sum] = "673b8809f4386be2d5265eb68d8c4904127c442f496fac2b0e49202ceae98665"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libgbm-26.1.1-2.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_mesa-libgbm;unpack=0"
SRC_URI[x86_64_v2_mesa-libgbm.sha256sum] = "3ca85eb908906d46ce2f531fa62ca7105c7d5832a523ef8f79a9a9d663c7423b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libgbm-devel-26.1.1-2.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_mesa-libgbm-devel;unpack=0"
SRC_URI[x86_64_v2_mesa-libgbm-devel.sha256sum] = "098ff0e04482ae3e6e06a2b78d8fb727c0a150e3db44dc9534a1e9f9a292780c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-vulkan-drivers-26.1.1-2.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_mesa-vulkan-drivers;unpack=0"
SRC_URI[x86_64_v2_mesa-vulkan-drivers.sha256sum] = "c3ffe31cae0529df72a71280ac002ad389757c82792274bf5e152d2a4bb630f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-dri-drivers-26.1.1-2.el10.alma.3.aarch64.rpm;name=aarch64_mesa-dri-drivers;unpack=0"
SRC_URI[aarch64_mesa-dri-drivers.sha256sum] = "38f980cc630b7f057e0c87fefa5dd3198edac6ebec5ec3737599a5e0d2723320"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-filesystem-26.1.1-2.el10.alma.3.aarch64.rpm;name=aarch64_mesa-filesystem;unpack=0"
SRC_URI[aarch64_mesa-filesystem.sha256sum] = "9e92e542e817d948c2ec6f892f4ae2cca0374401931461891df658f98eba71c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libEGL-26.1.1-2.el10.alma.3.aarch64.rpm;name=aarch64_mesa-libEGL;unpack=0"
SRC_URI[aarch64_mesa-libEGL.sha256sum] = "12342e0b4f2936b4891cd7963f861c75af10d625940c54d93e1bb14e18cb4942"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libEGL-devel-26.1.1-2.el10.alma.3.aarch64.rpm;name=aarch64_mesa-libEGL-devel;unpack=0"
SRC_URI[aarch64_mesa-libEGL-devel.sha256sum] = "d8aa205d3be0fc3745cf4bfacfb3d1ae6e6762a93de417ea566fa973109db90d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libGL-26.1.1-2.el10.alma.3.aarch64.rpm;name=aarch64_mesa-libGL;unpack=0"
SRC_URI[aarch64_mesa-libGL.sha256sum] = "248936914d7364e32c06e20b95a09ea299d74d5c12c54055c8de7b1f684cf326"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libGL-devel-26.1.1-2.el10.alma.3.aarch64.rpm;name=aarch64_mesa-libGL-devel;unpack=0"
SRC_URI[aarch64_mesa-libGL-devel.sha256sum] = "7fef9852f1ea4153cac49d195661fdea0df88cf3e2a5206021681dcf0ed54107"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libgbm-26.1.1-2.el10.alma.3.aarch64.rpm;name=aarch64_mesa-libgbm;unpack=0"
SRC_URI[aarch64_mesa-libgbm.sha256sum] = "88f2e3ceed1ba527ea4a4b26d96c37b3a30c0c096c7e4f41d08c89ad500cb4a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libgbm-devel-26.1.1-2.el10.alma.3.aarch64.rpm;name=aarch64_mesa-libgbm-devel;unpack=0"
SRC_URI[aarch64_mesa-libgbm-devel.sha256sum] = "ba04e3c4d83bdaee398151ac9636eea7693868a7bdda4491bc68adf2ebc31792"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-vulkan-drivers-26.1.1-2.el10.alma.3.aarch64.rpm;name=aarch64_mesa-vulkan-drivers;unpack=0"
SRC_URI[aarch64_mesa-vulkan-drivers.sha256sum] = "4e0cb569344030305fe565922779b98da67b642cd57eb3f1edcbb778ffa1d4ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/mesa-dri-drivers-26.1.1-2.el10.alma.3.riscv64.rpm;name=riscv64_mesa-dri-drivers;unpack=0"
SRC_URI[riscv64_mesa-dri-drivers.sha256sum] = "fbe67974833585d6464163efb1d771ca2300db0473c5c3340cfaf348d51526ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/mesa-filesystem-26.1.1-2.el10.alma.3.riscv64.rpm;name=riscv64_mesa-filesystem;unpack=0"
SRC_URI[riscv64_mesa-filesystem.sha256sum] = "1f3004ecaada6a0eadba14700f7decb4ecbe7d148e50578ed6334cc93967e945"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/mesa-libEGL-26.1.1-2.el10.alma.3.riscv64.rpm;name=riscv64_mesa-libEGL;unpack=0"
SRC_URI[riscv64_mesa-libEGL.sha256sum] = "b6b2bfc6d8b43ccd4330cacbc47af80f0316860bc4b442216b81d7a646f4be29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/mesa-libEGL-devel-26.1.1-2.el10.alma.3.riscv64.rpm;name=riscv64_mesa-libEGL-devel;unpack=0"
SRC_URI[riscv64_mesa-libEGL-devel.sha256sum] = "93c6bddfa41ee98d14072a8390e9ff182fc59425f47dc2019a26240337ef22ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/mesa-libGL-26.1.1-2.el10.alma.3.riscv64.rpm;name=riscv64_mesa-libGL;unpack=0"
SRC_URI[riscv64_mesa-libGL.sha256sum] = "5d703a2a4588c9fdfd49170b89f82b9990e3a59cd4bdb82f6edb61cb53bfd222"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/mesa-libGL-devel-26.1.1-2.el10.alma.3.riscv64.rpm;name=riscv64_mesa-libGL-devel;unpack=0"
SRC_URI[riscv64_mesa-libGL-devel.sha256sum] = "da28b1436fef854f5c0032fa2998dd9426ebd461e7d88a6cc71503afbf5fe79e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/mesa-libgbm-26.1.1-2.el10.alma.3.riscv64.rpm;name=riscv64_mesa-libgbm;unpack=0"
SRC_URI[riscv64_mesa-libgbm.sha256sum] = "8d1905f4f128c71cee3c4f44cb7e43c10f8d8caa2a19d7de796d6094efa6cd1e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/mesa-libgbm-devel-26.1.1-2.el10.alma.3.riscv64.rpm;name=riscv64_mesa-libgbm-devel;unpack=0"
SRC_URI[riscv64_mesa-libgbm-devel.sha256sum] = "9600b1bc0366717ebbd1a0fd032aed176137a2190fcf6f8554982bf87223aded"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/mesa-vulkan-drivers-26.1.1-2.el10.alma.3.riscv64.rpm;name=riscv64_mesa-vulkan-drivers;unpack=0"
SRC_URI[riscv64_mesa-vulkan-drivers.sha256sum] = "f469ce6b5af6105ad76da8b991c3b3c5c7e6fc9c165fc41831eeeeed973c1dfd"

RDEPENDS:mesa-dri-drivers = " \
 elfutils-libelf \
 expat \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libxcb \
 libxshmfence \
 libzstd \
 llvm-libs \
 mesa-filesystem \
 mesa-libgbm \
 spirv-tools-libs \
 zlib-ng-compat \
 "
RDEPENDS:mesa-filesystem = " \
 "
RDEPENDS:mesa-libEGL:x86_64_v2 = " \
 expat \
 glibc \
 libX11 \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libwayland-client \
 libxcb \
 mesa-dri-drivers \
 mesa-libgbm \
"
RDEPENDS:mesa-libEGL:aarch64 = " \
 expat \
 glibc \
 libX11 \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libwayland-client \
 libxcb \
 mesa-dri-drivers \
 mesa-libgbm \
"
RDEPENDS:mesa-libEGL:riscv64 = " \
 expat \
 glibc \
 libX11 \
 libX11-xcb \
 libdrm \
 libgcc \
 libglvnd-egl \
 libwayland-client \
 libxcb \
 mesa-dri-drivers \
 mesa-libgbm \
"
RDEPENDS:mesa-libEGL-devel = " \
 libglvnd-devel \
 mesa-libEGL \
 "
RDEPENDS:mesa-libGL:x86_64_v2 = " \
 expat \
 glibc \
 libX11 \
 libX11-xcb \
 libXext \
 libXxf86vm \
 libdrm \
 libglvnd-glx \
 libxcb \
 mesa-dri-drivers \
"
RDEPENDS:mesa-libGL:aarch64 = " \
 expat \
 glibc \
 libX11 \
 libX11-xcb \
 libXext \
 libXxf86vm \
 libdrm \
 libglvnd-glx \
 libxcb \
 mesa-dri-drivers \
"
RDEPENDS:mesa-libGL:riscv64 = " \
 expat \
 glibc \
 libX11 \
 libX11-xcb \
 libXext \
 libXxf86vm \
 libdrm \
 libgcc \
 libglvnd-glx \
 libxcb \
 mesa-dri-drivers \
"
RDEPENDS:mesa-libGL-devel = " \
 libdrm-devel \
 libglvnd-devel \
 mesa-libGL \
 pkgconf-pkg-config \
 "
RDEPENDS:mesa-libgbm:x86_64_v2 = " \
 expat \
 glibc \
 libdrm \
 mesa-dri-drivers \
"
RDEPENDS:mesa-libgbm:aarch64 = " \
 expat \
 glibc \
 libdrm \
 mesa-dri-drivers \
"
RDEPENDS:mesa-libgbm:riscv64 = " \
 expat \
 glibc \
 libdrm \
 libgcc \
 mesa-dri-drivers \
"
RDEPENDS:mesa-libgbm-devel = " \
 mesa-libgbm \
 pkgconf-pkg-config \
 "
RDEPENDS:mesa-vulkan-drivers = " \
 elfutils-libelf \
 expat \
 glibc \
 libX11-xcb \
 libdisplay-info \
 libdrm \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 libxshmfence \
 libzstd \
 llvm-libs \
 mesa-filesystem \
 spirv-tools-libs \
 systemd-libs \
 vulkan-loader \
 zlib-ng-compat \
 "
