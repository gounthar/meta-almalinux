# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iw"
PV = "6.17"
PR = "1.el10"
PACKAGES = " \
 iw \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iw-6.17-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2a34f1079ba6914b6c32da83e21ba47291e876cc3d15abc6a8f26535aeaead4e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iw-6.17-1.el10.x86_64_v2.rpm;name=x86_64_v2_iw;unpack=0"
SRC_URI[x86_64_v2_iw.sha256sum] = "e0cff7a4a8d362b0998d7cf4c02e6209a99c5958f1cd6fc95124e69f02c9b571"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iw-6.17-1.el10.aarch64.rpm;name=aarch64_iw;unpack=0"
SRC_URI[aarch64_iw.sha256sum] = "b5f7514f6129659e7ef0097b092f007107430dcdcac10744838e8e6b167e5603"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/riscv64/os/Packages/iw-6.17-1.el10.riscv64.rpm;name=riscv64_iw;unpack=0"
SRC_URI[riscv64_iw.sha256sum] = "1b663be28a216e1071f5d2d8ac8eedebe0a5bb2bc2bcfe007e443e2f56a81bab"

RDEPENDS:iw = " \
 glibc \
 libnl3 \
 "
