# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-user-dirs-gtk"
PV = "0.11"
PR = "6.el10"
PACKAGES = " \
 xdg-user-dirs-gtk \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xdg-user-dirs-gtk-0.11-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9999dd41ac206f9658668e3ab8a896f7c88ae3de356a4d44dff8efa7a7f6e050"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xdg-user-dirs-gtk-0.11-6.el10.x86_64_v2.rpm;name=x86_64_v2_xdg-user-dirs-gtk;unpack=0"
SRC_URI[x86_64_v2_xdg-user-dirs-gtk.sha256sum] = "2d7004ff06fe9e2eb4bf5674cfa676d793dca67f4ac9e15ab12d8c329272b0e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xdg-user-dirs-gtk-0.11-6.el10.aarch64.rpm;name=aarch64_xdg-user-dirs-gtk;unpack=0"
SRC_URI[aarch64_xdg-user-dirs-gtk.sha256sum] = "2fb0a192fdcbda7dd2ecd128a0151a52bfc7273b48a2fbc1a5e51a77a1243611"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/riscv64/os/Packages/xdg-user-dirs-gtk-0.11-6.el10.riscv64.rpm;name=riscv64_xdg-user-dirs-gtk;unpack=0"
SRC_URI[riscv64_xdg-user-dirs-gtk.sha256sum] = "9bdee0ed9e22342b683ccefd5b4658e66fb8c1a739f177074b5615f4ebc6bce8"

RDEPENDS:xdg-user-dirs-gtk = " \
 glib2 \
 glibc \
 gtk3 \
 xdg-user-dirs \
 "
